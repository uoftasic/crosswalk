v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {4C} 14110 -4800 0 0 0.4 0.4 {}
T {2C} 14470 -4780 0 0 0.4 0.4 {}
T {1C} 14720 -4780 0 0 0.4 0.4 {}
T {dummy} 15010 -4790 0 0 0.4 0.4 {}
T {4C} 250 -1020 0 0 0.4 0.4 {}
T {~clock & ~b2
~(clock + b2)} 640 -680 0 0 0.4 0.4 {}
T {~(~clock & b2)
clock + ~b2} 1760 -650 0 0 0.4 0.4 {}
T {2C} 260 -470 0 0 0.4 0.4 {}
T {dummy} 260 580 0 0 0.4 0.4 {}
T {~clock } 250 800 0 0 0.4 0.4 {}
T {GND Switch - on when b2 = 0} 420 -950 0 0 0.4 0.4 {}
T {VCC Switch - on when b2 = 1} 1320 -940 0 0 0.4 0.4 {}
T {Vin switch} 2030 -870 0 0 0.4 0.4 {}
T {NOR gate for GND} 350 -560 0 0 0.4 0.4 {}
T {b2 Inverter} 1050 -630 0 0 0.4 0.4 {}
T {out Inverter} 1570 -640 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 590 -140 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1710 -110 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 370 -410 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1270 -400 0 0 0.4 0.4 {}
T {Vin switch} 1980 -330 0 0 0.4 0.4 {}
T {NOR gate for GND} 300 -20 0 0 0.4 0.4 {}
T {b Inverter} 1000 -90 0 0 0.4 0.4 {}
T {out Inverter} 1520 -100 0 0 0.4 0.4 {}
T {1C} 270 40 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 600 370 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1720 400 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 380 100 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1280 110 0 0 0.4 0.4 {}
T {Vin switch} 1990 180 0 0 0.4 0.4 {}
T {NOR gate for GND} 310 490 0 0 0.4 0.4 {}
T {b Inverter} 1010 420 0 0 0.4 0.4 {}
T {out Inverter} 1530 410 0 0 0.4 0.4 {}
T {Simulate clock
using a pulse} 760 -3750 0 0 0.4 0.4 {}
T {Clock Inverter} 800 -3840 0 0 0.4 0.4 {}
T {8C} 300 -1570 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 630 -1240 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1750 -1210 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 410 -1510 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1310 -1500 0 0 0.4 0.4 {}
T {Vin switch} 2020 -1430 0 0 0.4 0.4 {}
T {NOR gate for GND} 340 -1120 0 0 0.4 0.4 {}
T {b Inverter} 1040 -1190 0 0 0.4 0.4 {}
T {out Inverter} 1560 -1200 0 0 0.4 0.4 {}
T {Used for all switches} 900 -4120 0 0 0.4 0.4 {}
T {16C} 290 -2100 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 620 -1770 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1740 -1740 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 400 -2040 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1300 -2030 0 0 0.4 0.4 {}
T {Vin switch} 2010 -1960 0 0 0.4 0.4 {}
T {NOR gate for GND} 330 -1650 0 0 0.4 0.4 {}
T {b Inverter} 1030 -1720 0 0 0.4 0.4 {}
T {out Inverter} 1550 -1730 0 0 0.4 0.4 {}
T {32C} 280 -2610 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 610 -2280 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1730 -2250 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 390 -2550 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1290 -2540 0 0 0.4 0.4 {}
T {Vin switch} 2000 -2470 0 0 0.4 0.4 {}
T {NOR gate for GND} 320 -2160 0 0 0.4 0.4 {}
T {b Inverter} 1020 -2230 0 0 0.4 0.4 {}
T {out Inverter} 1540 -2240 0 0 0.4 0.4 {}
T {64C} 290 -3140 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 620 -2810 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1740 -2780 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 400 -3080 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1300 -3070 0 0 0.4 0.4 {}
T {Vin switch} 2010 -3000 0 0 0.4 0.4 {}
T {NOR gate for GND} 330 -2690 0 0 0.4 0.4 {}
T {b Inverter} 1030 -2760 0 0 0.4 0.4 {}
T {out Inverter} 1550 -2770 0 0 0.4 0.4 {}
T {128C} 290 -3660 0 0 0.4 0.4 {}
T {~clock & ~b
~(clock + b)} 620 -3330 0 0 0.4 0.4 {}
T {~(~clock & b)
clock + ~b} 1740 -3300 0 0 0.4 0.4 {}
T {GND Switch - on when b = 0} 400 -3600 0 0 0.4 0.4 {}
T {VCC Switch - on when b = 1} 1300 -3590 0 0 0.4 0.4 {}
T {Vin switch} 2010 -3520 0 0 0.4 0.4 {}
T {NOR gate for GND} 330 -3210 0 0 0.4 0.4 {}
T {b Inverter} 1030 -3280 0 0 0.4 0.4 {}
T {out Inverter} 1550 -3290 0 0 0.4 0.4 {}
T {Vtop switch} 320 -4110 0 0 0.4 0.4 {}
T {8C} 13370 -4810 0 0 0.4 0.4 {}
T {16C} 12010 -4840 0 0 0.4 0.4 {}
T {32C} 9240 -4830 0 0 0.4 0.4 {}
T {64C} 3780 -4830 0 0 0.4 0.4 {}
N 14020 -4750 14130 -4750 {lab=top}
N 14130 -4750 14240 -4750 {lab=top}
N 14240 -4750 14350 -4750 {lab=top}
N 14020 -4690 14130 -4690 {lab=bot4c}
N 14130 -4690 14240 -4690 {lab=bot4c}
N 14240 -4690 14350 -4690 {lab=bot4c}
N 14510 -4750 14620 -4750 {lab=top}
N 14510 -4690 14620 -4690 {lab=bot2c}
N 14180 -4790 14180 -4750 {lab=top}
N 14560 -4790 14560 -4750 {lab=top}
N 14960 -4790 14960 -4750 {lab=top}
N 14790 -4790 14790 -4750 {lab=top}
N 14170 -4790 14970 -4790 {lab=top}
N 1820 -750 1820 -730 {lab=bot4c}
N 1820 -830 1820 -810 {lab=vdd}
N 2130 -810 2280 -810 {lab=vin}
N 2130 -750 2280 -750 {lab=bot4c}
N 2200 -750 2200 -730 {lab=bot4c}
N 2130 -780 2180 -780 {lab=0}
N 2260 -780 2280 -780 {lab=vdd}
N 14180 -4690 14180 -4660 {lab=bot4c}
N 2070 -780 2090 -780 {lab=clock}
N 2320 -780 2330 -780 {lab=~clock}
N 14560 -4690 14560 -4660 {lab=bot2c}
N 290 730 330 730 {lab=0}
N 530 690 680 690 {lab=vin}
N 530 750 680 750 {lab=dum}
N 600 750 600 770 {lab=dum}
N 530 720 580 720 {lab=0}
N 660 720 680 720 {lab=vdd}
N 470 720 490 720 {lab=clock}
N 720 720 730 720 {lab=~clock}
N 14580 -4850 14580 -4790 {lab=top}
N 400 -4020 440 -4020 {lab=#net1}
N 440 -4020 440 -3980 {lab=#net1}
N 340 -4020 340 -4000 {lab=0}
N 440 -3950 480 -3950 {lab=vdd}
N 1820 -780 1840 -780 {lab=vdd}
N 1840 -820 1840 -780 {lab=vdd}
N 1820 -820 1840 -820 {lab=vdd}
N 700 -790 720 -790 {lab=0}
N 720 -790 720 -760 {lab=0}
N 700 -760 720 -760 {lab=0}
N 450 -800 450 -780 {lab=#net2}
N 450 -720 450 -690 {lab=gndb2}
N 400 -690 450 -690 {lab=gndb2}
N 450 -830 460 -830 {lab=vdd}
N 460 -860 460 -830 {lab=vdd}
N 450 -860 460 -860 {lab=vdd}
N 450 -750 460 -750 {lab=#net2}
N 460 -780 460 -750 {lab=#net2}
N 450 -780 460 -780 {lab=#net2}
N 450 -690 510 -690 {lab=gndb2}
N 320 -830 410 -830 {lab=clock}
N 360 -830 360 -660 {lab=clock}
N 400 -750 410 -750 {lab=b2}
N 400 -630 510 -630 {lab=0}
N 450 -630 450 -610 {lab=0}
N 450 -710 480 -710 {lab=gndb2}
N 1380 -800 1380 -780 {lab=#net3}
N 1380 -720 1380 -690 {lab=out2}
N 1330 -690 1380 -690 {lab=out2}
N 1380 -830 1390 -830 {lab=vdd}
N 1390 -860 1390 -830 {lab=vdd}
N 1380 -860 1390 -860 {lab=vdd}
N 1380 -750 1390 -750 {lab=#net3}
N 1390 -780 1390 -750 {lab=#net3}
N 1380 -780 1390 -780 {lab=#net3}
N 1380 -690 1440 -690 {lab=out2}
N 1250 -830 1340 -830 {lab=clock}
N 1290 -830 1290 -660 {lab=clock}
N 1330 -750 1340 -750 {lab=~b2}
N 1330 -630 1440 -630 {lab=0}
N 1380 -630 1380 -610 {lab=0}
N 1380 -710 1410 -710 {lab=out2}
N 1110 -770 1110 -740 {lab=~b2}
N 1040 -800 1070 -800 {lab=b2}
N 1040 -800 1040 -710 {lab=b2}
N 1040 -710 1070 -710 {lab=b2}
N 1110 -800 1170 -800 {lab=vdd}
N 1170 -840 1170 -800 {lab=vdd}
N 1110 -840 1170 -840 {lab=vdd}
N 1110 -710 1160 -710 {lab=0}
N 1160 -710 1160 -670 {lab=0}
N 1110 -670 1160 -670 {lab=0}
N 1110 -680 1110 -660 {lab=0}
N 1110 -850 1110 -830 {lab=vdd}
N 1010 -760 1040 -760 {lab=b2}
N 1110 -750 1120 -750 {lab=~b2}
N 1630 -780 1630 -750 {lab=~out2}
N 1560 -810 1590 -810 {lab=out2}
N 1560 -810 1560 -720 {lab=out2}
N 1560 -720 1590 -720 {lab=out2}
N 1630 -810 1690 -810 {lab=vdd}
N 1690 -850 1690 -810 {lab=vdd}
N 1630 -850 1690 -850 {lab=vdd}
N 1630 -720 1680 -720 {lab=0}
N 1680 -720 1680 -680 {lab=0}
N 1630 -680 1680 -680 {lab=0}
N 1630 -690 1630 -670 {lab=0}
N 1630 -860 1630 -840 {lab=vdd}
N 1530 -770 1560 -770 {lab=out2}
N 1630 -760 1640 -760 {lab=~out2}
N 1770 -210 1770 -190 {lab=bot2c}
N 1770 -290 1770 -270 {lab=vdd}
N 2080 -270 2230 -270 {lab=vin}
N 2080 -210 2230 -210 {lab=bot2c}
N 2150 -210 2150 -190 {lab=bot2c}
N 2080 -240 2130 -240 {lab=0}
N 2210 -240 2230 -240 {lab=vdd}
N 2020 -240 2040 -240 {lab=clock}
N 2270 -240 2280 -240 {lab=~clock}
N 1770 -240 1790 -240 {lab=vdd}
N 1790 -280 1790 -240 {lab=vdd}
N 1770 -280 1790 -280 {lab=vdd}
N 650 -250 670 -250 {lab=0}
N 670 -250 670 -220 {lab=0}
N 650 -220 670 -220 {lab=0}
N 400 -260 400 -240 {lab=#net4}
N 400 -180 400 -150 {lab=gndb1}
N 350 -150 400 -150 {lab=gndb1}
N 400 -290 410 -290 {lab=vdd}
N 410 -320 410 -290 {lab=vdd}
N 400 -320 410 -320 {lab=vdd}
N 400 -210 410 -210 {lab=#net4}
N 410 -240 410 -210 {lab=#net4}
N 400 -240 410 -240 {lab=#net4}
N 400 -150 460 -150 {lab=gndb1}
N 270 -290 360 -290 {lab=clock}
N 310 -290 310 -120 {lab=clock}
N 350 -210 360 -210 {lab=b1}
N 350 -90 460 -90 {lab=0}
N 400 -90 400 -70 {lab=0}
N 400 -170 430 -170 {lab=gndb1}
N 1330 -260 1330 -240 {lab=#net5}
N 1330 -180 1330 -150 {lab=out1}
N 1280 -150 1330 -150 {lab=out1}
N 1330 -290 1340 -290 {lab=vdd}
N 1340 -320 1340 -290 {lab=vdd}
N 1330 -320 1340 -320 {lab=vdd}
N 1330 -210 1340 -210 {lab=#net5}
N 1340 -240 1340 -210 {lab=#net5}
N 1330 -240 1340 -240 {lab=#net5}
N 1330 -150 1390 -150 {lab=out1}
N 1200 -290 1290 -290 {lab=clock}
N 1240 -290 1240 -120 {lab=clock}
N 1280 -210 1290 -210 {lab=~b1}
N 1280 -90 1390 -90 {lab=0}
N 1330 -90 1330 -70 {lab=0}
N 1330 -170 1360 -170 {lab=out1}
N 1060 -230 1060 -200 {lab=~b1}
N 990 -260 1020 -260 {lab=b1}
N 990 -260 990 -170 {lab=b1}
N 990 -170 1020 -170 {lab=b1}
N 1060 -260 1120 -260 {lab=vdd}
N 1120 -300 1120 -260 {lab=vdd}
N 1060 -300 1120 -300 {lab=vdd}
N 1060 -170 1110 -170 {lab=0}
N 1110 -170 1110 -130 {lab=0}
N 1060 -130 1110 -130 {lab=0}
N 1060 -140 1060 -120 {lab=0}
N 1060 -310 1060 -290 {lab=vdd}
N 960 -220 990 -220 {lab=b1}
N 1060 -210 1070 -210 {lab=~b1}
N 1580 -240 1580 -210 {lab=~out1}
N 1510 -270 1540 -270 {lab=out1}
N 1510 -270 1510 -180 {lab=out1}
N 1510 -180 1540 -180 {lab=out1}
N 1580 -270 1640 -270 {lab=vdd}
N 1640 -310 1640 -270 {lab=vdd}
N 1580 -310 1640 -310 {lab=vdd}
N 1580 -180 1630 -180 {lab=0}
N 1630 -180 1630 -140 {lab=0}
N 1580 -140 1630 -140 {lab=0}
N 1580 -150 1580 -130 {lab=0}
N 1580 -320 1580 -300 {lab=vdd}
N 1480 -230 1510 -230 {lab=out1}
N 1580 -220 1590 -220 {lab=~out1}
N 1780 300 1780 320 {lab=bot1c}
N 1780 220 1780 240 {lab=vdd}
N 2090 240 2240 240 {lab=vin}
N 2090 300 2240 300 {lab=bot1c}
N 2160 300 2160 320 {lab=bot1c}
N 2090 270 2140 270 {lab=0}
N 2220 270 2240 270 {lab=vdd}
N 2030 270 2050 270 {lab=clock}
N 2280 270 2290 270 {lab=~clock}
N 1780 270 1800 270 {lab=vdd}
N 1800 230 1800 270 {lab=vdd}
N 1780 230 1800 230 {lab=vdd}
N 660 260 680 260 {lab=0}
N 680 260 680 290 {lab=0}
N 660 290 680 290 {lab=0}
N 410 250 410 270 {lab=#net6}
N 410 330 410 360 {lab=gndb0}
N 360 360 410 360 {lab=gndb0}
N 410 220 420 220 {lab=vdd}
N 420 190 420 220 {lab=vdd}
N 410 190 420 190 {lab=vdd}
N 410 300 420 300 {lab=#net6}
N 420 270 420 300 {lab=#net6}
N 410 270 420 270 {lab=#net6}
N 410 360 470 360 {lab=gndb0}
N 280 220 370 220 {lab=clock}
N 320 220 320 390 {lab=clock}
N 360 300 370 300 {lab=b0}
N 360 420 470 420 {lab=0}
N 410 420 410 440 {lab=0}
N 410 340 440 340 {lab=gndb0}
N 1340 250 1340 270 {lab=#net7}
N 1340 330 1340 360 {lab=out0}
N 1290 360 1340 360 {lab=out0}
N 1340 220 1350 220 {lab=vdd}
N 1350 190 1350 220 {lab=vdd}
N 1340 190 1350 190 {lab=vdd}
N 1340 300 1350 300 {lab=#net7}
N 1350 270 1350 300 {lab=#net7}
N 1340 270 1350 270 {lab=#net7}
N 1340 360 1400 360 {lab=out0}
N 1210 220 1300 220 {lab=clock}
N 1250 220 1250 390 {lab=clock}
N 1290 300 1300 300 {lab=~b0}
N 1290 420 1400 420 {lab=0}
N 1340 420 1340 440 {lab=0}
N 1340 340 1370 340 {lab=out0}
N 1070 280 1070 310 {lab=~b0}
N 1000 250 1030 250 {lab=b0}
N 1000 250 1000 340 {lab=b0}
N 1000 340 1030 340 {lab=b0}
N 1070 250 1130 250 {lab=vdd}
N 1130 210 1130 250 {lab=vdd}
N 1070 210 1130 210 {lab=vdd}
N 1070 340 1120 340 {lab=0}
N 1120 340 1120 380 {lab=0}
N 1070 380 1120 380 {lab=0}
N 1070 370 1070 390 {lab=0}
N 1070 200 1070 220 {lab=vdd}
N 970 290 1000 290 {lab=b0}
N 1070 300 1080 300 {lab=~b0}
N 1590 270 1590 300 {lab=~out0}
N 1520 240 1550 240 {lab=out0}
N 1520 240 1520 330 {lab=out0}
N 1520 330 1550 330 {lab=out0}
N 1590 240 1650 240 {lab=vdd}
N 1650 200 1650 240 {lab=vdd}
N 1590 200 1650 200 {lab=vdd}
N 1590 330 1640 330 {lab=0}
N 1640 330 1640 370 {lab=0}
N 1590 370 1640 370 {lab=0}
N 1590 360 1590 380 {lab=0}
N 1590 190 1590 210 {lab=vdd}
N 1490 280 1520 280 {lab=out0}
N 1590 290 1600 290 {lab=~out0}
N 880 -3980 880 -3950 {lab=~clock}
N 810 -4010 840 -4010 {lab=clock}
N 810 -4010 810 -3920 {lab=clock}
N 810 -3920 840 -3920 {lab=clock}
N 880 -4010 940 -4010 {lab=vdd}
N 940 -4050 940 -4010 {lab=vdd}
N 880 -4050 940 -4050 {lab=vdd}
N 880 -3920 930 -3920 {lab=0}
N 930 -3920 930 -3880 {lab=0}
N 880 -3880 930 -3880 {lab=0}
N 880 -3890 880 -3870 {lab=0}
N 880 -4060 880 -4040 {lab=vdd}
N 780 -3970 810 -3970 {lab=clock}
N 880 -3960 890 -3960 {lab=~clock}
N 1810 -1310 1810 -1290 {lab=bot8c}
N 1810 -1390 1810 -1370 {lab=vdd}
N 2120 -1370 2270 -1370 {lab=vin}
N 2120 -1310 2270 -1310 {lab=bot8c}
N 2190 -1310 2190 -1290 {lab=bot8c}
N 2120 -1340 2170 -1340 {lab=0}
N 2250 -1340 2270 -1340 {lab=vdd}
N 2060 -1340 2080 -1340 {lab=clock}
N 2310 -1340 2320 -1340 {lab=~clock}
N 1810 -1340 1830 -1340 {lab=vdd}
N 1830 -1380 1830 -1340 {lab=vdd}
N 1810 -1380 1830 -1380 {lab=vdd}
N 690 -1350 710 -1350 {lab=0}
N 710 -1350 710 -1320 {lab=0}
N 690 -1320 710 -1320 {lab=0}
N 440 -1360 440 -1340 {lab=#net8}
N 440 -1280 440 -1250 {lab=gndb3}
N 390 -1250 440 -1250 {lab=gndb3}
N 440 -1390 450 -1390 {lab=vdd}
N 450 -1420 450 -1390 {lab=vdd}
N 440 -1420 450 -1420 {lab=vdd}
N 440 -1310 450 -1310 {lab=#net8}
N 450 -1340 450 -1310 {lab=#net8}
N 440 -1340 450 -1340 {lab=#net8}
N 440 -1250 500 -1250 {lab=gndb3}
N 310 -1390 400 -1390 {lab=clock}
N 350 -1390 350 -1220 {lab=clock}
N 390 -1310 400 -1310 {lab=b3}
N 390 -1190 500 -1190 {lab=0}
N 440 -1190 440 -1170 {lab=0}
N 440 -1270 470 -1270 {lab=gndb3}
N 1370 -1360 1370 -1340 {lab=#net9}
N 1370 -1280 1370 -1250 {lab=out3}
N 1320 -1250 1370 -1250 {lab=out3}
N 1370 -1390 1380 -1390 {lab=vdd}
N 1380 -1420 1380 -1390 {lab=vdd}
N 1370 -1420 1380 -1420 {lab=vdd}
N 1370 -1310 1380 -1310 {lab=#net9}
N 1380 -1340 1380 -1310 {lab=#net9}
N 1370 -1340 1380 -1340 {lab=#net9}
N 1370 -1250 1430 -1250 {lab=out3}
N 1240 -1390 1330 -1390 {lab=clock}
N 1280 -1390 1280 -1220 {lab=clock}
N 1320 -1310 1330 -1310 {lab=~b3}
N 1320 -1190 1430 -1190 {lab=0}
N 1370 -1190 1370 -1170 {lab=0}
N 1370 -1270 1400 -1270 {lab=out3}
N 1100 -1330 1100 -1300 {lab=~b3}
N 1030 -1360 1060 -1360 {lab=b3}
N 1030 -1360 1030 -1270 {lab=b3}
N 1030 -1270 1060 -1270 {lab=b3}
N 1100 -1360 1160 -1360 {lab=vdd}
N 1160 -1400 1160 -1360 {lab=vdd}
N 1100 -1400 1160 -1400 {lab=vdd}
N 1100 -1270 1150 -1270 {lab=0}
N 1150 -1270 1150 -1230 {lab=0}
N 1100 -1230 1150 -1230 {lab=0}
N 1100 -1240 1100 -1220 {lab=0}
N 1100 -1410 1100 -1390 {lab=vdd}
N 1000 -1320 1030 -1320 {lab=b3}
N 1100 -1310 1110 -1310 {lab=~b3}
N 1620 -1340 1620 -1310 {lab=~out3}
N 1550 -1370 1580 -1370 {lab=out3}
N 1550 -1370 1550 -1280 {lab=out3}
N 1550 -1280 1580 -1280 {lab=out3}
N 1620 -1370 1680 -1370 {lab=vdd}
N 1680 -1410 1680 -1370 {lab=vdd}
N 1620 -1410 1680 -1410 {lab=vdd}
N 1620 -1280 1670 -1280 {lab=0}
N 1670 -1280 1670 -1240 {lab=0}
N 1620 -1240 1670 -1240 {lab=0}
N 1620 -1250 1620 -1230 {lab=0}
N 1620 -1420 1620 -1400 {lab=vdd}
N 1520 -1330 1550 -1330 {lab=out3}
N 1620 -1320 1630 -1320 {lab=~out3}
N 1800 -1840 1800 -1820 {lab=bot16c}
N 1800 -1920 1800 -1900 {lab=vdd}
N 2110 -1900 2260 -1900 {lab=vin}
N 2110 -1840 2260 -1840 {lab=bot16c}
N 2180 -1840 2180 -1820 {lab=bot16c}
N 2110 -1870 2160 -1870 {lab=0}
N 2240 -1870 2260 -1870 {lab=vdd}
N 2050 -1870 2070 -1870 {lab=clock}
N 2300 -1870 2310 -1870 {lab=~clock}
N 1800 -1870 1820 -1870 {lab=vdd}
N 1820 -1910 1820 -1870 {lab=vdd}
N 1800 -1910 1820 -1910 {lab=vdd}
N 680 -1880 700 -1880 {lab=0}
N 700 -1880 700 -1850 {lab=0}
N 680 -1850 700 -1850 {lab=0}
N 430 -1890 430 -1870 {lab=#net10}
N 430 -1810 430 -1780 {lab=gndb4}
N 380 -1780 430 -1780 {lab=gndb4}
N 430 -1920 440 -1920 {lab=vdd}
N 440 -1950 440 -1920 {lab=vdd}
N 430 -1950 440 -1950 {lab=vdd}
N 430 -1840 440 -1840 {lab=#net10}
N 440 -1870 440 -1840 {lab=#net10}
N 430 -1870 440 -1870 {lab=#net10}
N 430 -1780 490 -1780 {lab=gndb4}
N 300 -1920 390 -1920 {lab=clock}
N 340 -1920 340 -1750 {lab=clock}
N 380 -1840 390 -1840 {lab=b4}
N 380 -1720 490 -1720 {lab=0}
N 430 -1720 430 -1700 {lab=0}
N 430 -1800 460 -1800 {lab=gndb4}
N 1360 -1890 1360 -1870 {lab=#net11}
N 1360 -1810 1360 -1780 {lab=out4}
N 1310 -1780 1360 -1780 {lab=out4}
N 1360 -1920 1370 -1920 {lab=vdd}
N 1370 -1950 1370 -1920 {lab=vdd}
N 1360 -1950 1370 -1950 {lab=vdd}
N 1360 -1840 1370 -1840 {lab=#net11}
N 1370 -1870 1370 -1840 {lab=#net11}
N 1360 -1870 1370 -1870 {lab=#net11}
N 1360 -1780 1420 -1780 {lab=out4}
N 1230 -1920 1320 -1920 {lab=clock}
N 1270 -1920 1270 -1750 {lab=clock}
N 1310 -1840 1320 -1840 {lab=~b4}
N 1310 -1720 1420 -1720 {lab=0}
N 1360 -1720 1360 -1700 {lab=0}
N 1360 -1800 1390 -1800 {lab=out4}
N 1090 -1860 1090 -1830 {lab=~b4}
N 1020 -1890 1050 -1890 {lab=b4}
N 1020 -1890 1020 -1800 {lab=b4}
N 1020 -1800 1050 -1800 {lab=b4}
N 1090 -1890 1150 -1890 {lab=vdd}
N 1150 -1930 1150 -1890 {lab=vdd}
N 1090 -1930 1150 -1930 {lab=vdd}
N 1090 -1800 1140 -1800 {lab=0}
N 1140 -1800 1140 -1760 {lab=0}
N 1090 -1760 1140 -1760 {lab=0}
N 1090 -1770 1090 -1750 {lab=0}
N 1090 -1940 1090 -1920 {lab=vdd}
N 990 -1850 1020 -1850 {lab=b4}
N 1090 -1840 1100 -1840 {lab=~b4}
N 1610 -1870 1610 -1840 {lab=~out4}
N 1540 -1900 1570 -1900 {lab=out4}
N 1540 -1900 1540 -1810 {lab=out4}
N 1540 -1810 1570 -1810 {lab=out4}
N 1610 -1900 1670 -1900 {lab=vdd}
N 1670 -1940 1670 -1900 {lab=vdd}
N 1610 -1940 1670 -1940 {lab=vdd}
N 1610 -1810 1660 -1810 {lab=0}
N 1660 -1810 1660 -1770 {lab=0}
N 1610 -1770 1660 -1770 {lab=0}
N 1610 -1780 1610 -1760 {lab=0}
N 1610 -1950 1610 -1930 {lab=vdd}
N 1510 -1860 1540 -1860 {lab=out4}
N 1610 -1850 1620 -1850 {lab=~out4}
N 1790 -2350 1790 -2330 {lab=bot32c}
N 1790 -2430 1790 -2410 {lab=vdd}
N 2100 -2410 2250 -2410 {lab=vin}
N 2100 -2350 2250 -2350 {lab=bot32c}
N 2170 -2350 2170 -2330 {lab=bot32c}
N 2100 -2380 2150 -2380 {lab=0}
N 2230 -2380 2250 -2380 {lab=vdd}
N 2040 -2380 2060 -2380 {lab=clock}
N 2290 -2380 2300 -2380 {lab=~clock}
N 1790 -2380 1810 -2380 {lab=vdd}
N 1810 -2420 1810 -2380 {lab=vdd}
N 1790 -2420 1810 -2420 {lab=vdd}
N 670 -2390 690 -2390 {lab=0}
N 690 -2390 690 -2360 {lab=0}
N 670 -2360 690 -2360 {lab=0}
N 420 -2400 420 -2380 {lab=#net12}
N 420 -2320 420 -2290 {lab=gndb5}
N 370 -2290 420 -2290 {lab=gndb5}
N 420 -2430 430 -2430 {lab=vdd}
N 430 -2460 430 -2430 {lab=vdd}
N 420 -2460 430 -2460 {lab=vdd}
N 420 -2350 430 -2350 {lab=#net12}
N 430 -2380 430 -2350 {lab=#net12}
N 420 -2380 430 -2380 {lab=#net12}
N 420 -2290 480 -2290 {lab=gndb5}
N 290 -2430 380 -2430 {lab=clock}
N 330 -2430 330 -2260 {lab=clock}
N 370 -2350 380 -2350 {lab=b5}
N 370 -2230 480 -2230 {lab=0}
N 420 -2230 420 -2210 {lab=0}
N 420 -2310 450 -2310 {lab=gndb5}
N 1350 -2400 1350 -2380 {lab=#net13}
N 1350 -2320 1350 -2290 {lab=out5}
N 1300 -2290 1350 -2290 {lab=out5}
N 1350 -2430 1360 -2430 {lab=vdd}
N 1360 -2460 1360 -2430 {lab=vdd}
N 1350 -2460 1360 -2460 {lab=vdd}
N 1350 -2350 1360 -2350 {lab=#net13}
N 1360 -2380 1360 -2350 {lab=#net13}
N 1350 -2380 1360 -2380 {lab=#net13}
N 1350 -2290 1410 -2290 {lab=out5}
N 1220 -2430 1310 -2430 {lab=clock}
N 1260 -2430 1260 -2260 {lab=clock}
N 1300 -2350 1310 -2350 {lab=~b5}
N 1300 -2230 1410 -2230 {lab=0}
N 1350 -2230 1350 -2210 {lab=0}
N 1350 -2310 1380 -2310 {lab=out5}
N 1080 -2370 1080 -2340 {lab=~b5}
N 1010 -2400 1040 -2400 {lab=b5}
N 1010 -2400 1010 -2310 {lab=b5}
N 1010 -2310 1040 -2310 {lab=b5}
N 1080 -2400 1140 -2400 {lab=vdd}
N 1140 -2440 1140 -2400 {lab=vdd}
N 1080 -2440 1140 -2440 {lab=vdd}
N 1080 -2310 1130 -2310 {lab=0}
N 1130 -2310 1130 -2270 {lab=0}
N 1080 -2270 1130 -2270 {lab=0}
N 1080 -2280 1080 -2260 {lab=0}
N 1080 -2450 1080 -2430 {lab=vdd}
N 980 -2360 1010 -2360 {lab=b5}
N 1080 -2350 1090 -2350 {lab=~b5}
N 1600 -2380 1600 -2350 {lab=~out5}
N 1530 -2410 1560 -2410 {lab=out5}
N 1530 -2410 1530 -2320 {lab=out5}
N 1530 -2320 1560 -2320 {lab=out5}
N 1600 -2410 1660 -2410 {lab=vdd}
N 1660 -2450 1660 -2410 {lab=vdd}
N 1600 -2450 1660 -2450 {lab=vdd}
N 1600 -2320 1650 -2320 {lab=0}
N 1650 -2320 1650 -2280 {lab=0}
N 1600 -2280 1650 -2280 {lab=0}
N 1600 -2290 1600 -2270 {lab=0}
N 1600 -2460 1600 -2440 {lab=vdd}
N 1500 -2370 1530 -2370 {lab=out5}
N 1600 -2360 1610 -2360 {lab=~out5}
N 1800 -2880 1800 -2860 {lab=bot64c}
N 1800 -2960 1800 -2940 {lab=vdd}
N 2110 -2940 2260 -2940 {lab=vin}
N 2110 -2880 2260 -2880 {lab=bot64c}
N 2180 -2880 2180 -2860 {lab=bot64c}
N 2110 -2910 2160 -2910 {lab=0}
N 2240 -2910 2260 -2910 {lab=vdd}
N 2050 -2910 2070 -2910 {lab=clock}
N 2300 -2910 2310 -2910 {lab=~clock}
N 1800 -2910 1820 -2910 {lab=vdd}
N 1820 -2950 1820 -2910 {lab=vdd}
N 1800 -2950 1820 -2950 {lab=vdd}
N 680 -2920 700 -2920 {lab=0}
N 700 -2920 700 -2890 {lab=0}
N 680 -2890 700 -2890 {lab=0}
N 430 -2930 430 -2910 {lab=#net14}
N 430 -2850 430 -2820 {lab=gndb6}
N 380 -2820 430 -2820 {lab=gndb6}
N 430 -2960 440 -2960 {lab=vdd}
N 440 -2990 440 -2960 {lab=vdd}
N 430 -2990 440 -2990 {lab=vdd}
N 430 -2880 440 -2880 {lab=#net14}
N 440 -2910 440 -2880 {lab=#net14}
N 430 -2910 440 -2910 {lab=#net14}
N 430 -2820 490 -2820 {lab=gndb6}
N 300 -2960 390 -2960 {lab=clock}
N 340 -2960 340 -2790 {lab=clock}
N 380 -2880 390 -2880 {lab=b6}
N 380 -2760 490 -2760 {lab=0}
N 430 -2760 430 -2740 {lab=0}
N 430 -2840 460 -2840 {lab=gndb6}
N 1360 -2930 1360 -2910 {lab=#net15}
N 1360 -2850 1360 -2820 {lab=out6}
N 1310 -2820 1360 -2820 {lab=out6}
N 1360 -2960 1370 -2960 {lab=vdd}
N 1370 -2990 1370 -2960 {lab=vdd}
N 1360 -2990 1370 -2990 {lab=vdd}
N 1360 -2880 1370 -2880 {lab=#net15}
N 1370 -2910 1370 -2880 {lab=#net15}
N 1360 -2910 1370 -2910 {lab=#net15}
N 1360 -2820 1420 -2820 {lab=out6}
N 1230 -2960 1320 -2960 {lab=clock}
N 1270 -2960 1270 -2790 {lab=clock}
N 1310 -2880 1320 -2880 {lab=~b6}
N 1310 -2760 1420 -2760 {lab=0}
N 1360 -2760 1360 -2740 {lab=0}
N 1360 -2840 1390 -2840 {lab=out6}
N 1090 -2900 1090 -2870 {lab=~b6}
N 1020 -2930 1050 -2930 {lab=b6}
N 1020 -2930 1020 -2840 {lab=b6}
N 1020 -2840 1050 -2840 {lab=b6}
N 1090 -2930 1150 -2930 {lab=vdd}
N 1150 -2970 1150 -2930 {lab=vdd}
N 1090 -2970 1150 -2970 {lab=vdd}
N 1090 -2840 1140 -2840 {lab=0}
N 1140 -2840 1140 -2800 {lab=0}
N 1090 -2800 1140 -2800 {lab=0}
N 1090 -2810 1090 -2790 {lab=0}
N 1090 -2980 1090 -2960 {lab=vdd}
N 990 -2890 1020 -2890 {lab=b6}
N 1090 -2880 1100 -2880 {lab=~b6}
N 1610 -2910 1610 -2880 {lab=~out6}
N 1540 -2940 1570 -2940 {lab=out6}
N 1540 -2940 1540 -2850 {lab=out6}
N 1540 -2850 1570 -2850 {lab=out6}
N 1610 -2940 1670 -2940 {lab=vdd}
N 1670 -2980 1670 -2940 {lab=vdd}
N 1610 -2980 1670 -2980 {lab=vdd}
N 1610 -2850 1660 -2850 {lab=0}
N 1660 -2850 1660 -2810 {lab=0}
N 1610 -2810 1660 -2810 {lab=0}
N 1610 -2820 1610 -2800 {lab=0}
N 1610 -2990 1610 -2970 {lab=vdd}
N 1510 -2900 1540 -2900 {lab=out6}
N 1610 -2890 1620 -2890 {lab=~out6}
N 1800 -3400 1800 -3380 {lab=bot128c}
N 1800 -3480 1800 -3460 {lab=vdd}
N 2110 -3460 2260 -3460 {lab=vin}
N 2110 -3400 2260 -3400 {lab=bot128c}
N 2180 -3400 2180 -3380 {lab=bot128c}
N 2110 -3430 2160 -3430 {lab=0}
N 2240 -3430 2260 -3430 {lab=vdd}
N 2050 -3430 2070 -3430 {lab=clock}
N 2300 -3430 2310 -3430 {lab=~clock}
N 1800 -3430 1820 -3430 {lab=vdd}
N 1820 -3470 1820 -3430 {lab=vdd}
N 1800 -3470 1820 -3470 {lab=vdd}
N 680 -3440 700 -3440 {lab=0}
N 700 -3440 700 -3410 {lab=0}
N 680 -3410 700 -3410 {lab=0}
N 430 -3450 430 -3430 {lab=#net16}
N 430 -3370 430 -3340 {lab=gndb7}
N 380 -3340 430 -3340 {lab=gndb7}
N 430 -3480 440 -3480 {lab=vdd}
N 440 -3510 440 -3480 {lab=vdd}
N 430 -3510 440 -3510 {lab=vdd}
N 430 -3400 440 -3400 {lab=#net16}
N 440 -3430 440 -3400 {lab=#net16}
N 430 -3430 440 -3430 {lab=#net16}
N 430 -3340 490 -3340 {lab=gndb7}
N 300 -3480 390 -3480 {lab=clock}
N 340 -3480 340 -3310 {lab=clock}
N 380 -3400 390 -3400 {lab=b7}
N 380 -3280 490 -3280 {lab=0}
N 430 -3280 430 -3260 {lab=0}
N 430 -3360 460 -3360 {lab=gndb7}
N 1360 -3450 1360 -3430 {lab=#net17}
N 1360 -3370 1360 -3340 {lab=out7}
N 1310 -3340 1360 -3340 {lab=out7}
N 1360 -3480 1370 -3480 {lab=vdd}
N 1370 -3510 1370 -3480 {lab=vdd}
N 1360 -3510 1370 -3510 {lab=vdd}
N 1360 -3400 1370 -3400 {lab=#net17}
N 1370 -3430 1370 -3400 {lab=#net17}
N 1360 -3430 1370 -3430 {lab=#net17}
N 1360 -3340 1420 -3340 {lab=out7}
N 1230 -3480 1320 -3480 {lab=clock}
N 1270 -3480 1270 -3310 {lab=clock}
N 1310 -3400 1320 -3400 {lab=~b7}
N 1310 -3280 1420 -3280 {lab=0}
N 1360 -3280 1360 -3260 {lab=0}
N 1360 -3360 1390 -3360 {lab=out7}
N 1090 -3420 1090 -3390 {lab=~b7}
N 1020 -3450 1050 -3450 {lab=b7}
N 1020 -3450 1020 -3360 {lab=b7}
N 1020 -3360 1050 -3360 {lab=b7}
N 1090 -3450 1150 -3450 {lab=vdd}
N 1150 -3490 1150 -3450 {lab=vdd}
N 1090 -3490 1150 -3490 {lab=vdd}
N 1090 -3360 1140 -3360 {lab=0}
N 1140 -3360 1140 -3320 {lab=0}
N 1090 -3320 1140 -3320 {lab=0}
N 1090 -3330 1090 -3310 {lab=0}
N 1090 -3500 1090 -3480 {lab=vdd}
N 990 -3410 1020 -3410 {lab=b7}
N 1090 -3400 1100 -3400 {lab=~b7}
N 1610 -3430 1610 -3400 {lab=~out7}
N 1540 -3460 1570 -3460 {lab=out7}
N 1540 -3460 1540 -3370 {lab=out7}
N 1540 -3370 1570 -3370 {lab=out7}
N 1610 -3460 1670 -3460 {lab=vdd}
N 1670 -3500 1670 -3460 {lab=vdd}
N 1610 -3500 1670 -3500 {lab=vdd}
N 1610 -3370 1660 -3370 {lab=0}
N 1660 -3370 1660 -3330 {lab=0}
N 1610 -3330 1660 -3330 {lab=0}
N 1610 -3340 1610 -3320 {lab=0}
N 1610 -3510 1610 -3490 {lab=vdd}
N 1510 -3420 1540 -3420 {lab=out7}
N 1610 -3410 1620 -3410 {lab=~out7}
N 13500 -4750 13610 -4750 {lab=top}
N 13610 -4750 13720 -4750 {lab=top}
N 13720 -4750 13830 -4750 {lab=top}
N 13500 -4690 13610 -4690 {lab=bot8c}
N 13610 -4690 13720 -4690 {lab=bot8c}
N 13720 -4690 13830 -4690 {lab=bot8c}
N 13040 -4750 13150 -4750 {lab=top}
N 13150 -4750 13260 -4750 {lab=top}
N 13260 -4750 13370 -4750 {lab=top}
N 13040 -4690 13150 -4690 {lab=bot8c}
N 13150 -4690 13260 -4690 {lab=bot8c}
N 13260 -4690 13370 -4690 {lab=bot8c}
N 13370 -4750 13500 -4750 {lab=top}
N 13370 -4690 13500 -4690 {lab=bot8c}
N 13430 -4690 13430 -4660 {lab=bot8c}
N 13430 -4790 14180 -4790 {lab=top}
N 13430 -4800 13430 -4750 {lab=top}
N 12530 -4750 12640 -4750 {lab=top}
N 12640 -4750 12750 -4750 {lab=top}
N 12750 -4750 12860 -4750 {lab=top}
N 12530 -4690 12640 -4690 {lab=bot16c}
N 12640 -4690 12750 -4690 {lab=bot16c}
N 12750 -4690 12860 -4690 {lab=bot16c}
N 12070 -4750 12180 -4750 {lab=top}
N 12180 -4750 12290 -4750 {lab=top}
N 12290 -4750 12400 -4750 {lab=top}
N 12070 -4690 12180 -4690 {lab=bot16c}
N 12180 -4690 12290 -4690 {lab=bot16c}
N 12290 -4690 12400 -4690 {lab=bot16c}
N 12400 -4750 12530 -4750 {lab=top}
N 12400 -4690 12530 -4690 {lab=bot16c}
N 11650 -4750 11760 -4750 {lab=top}
N 11760 -4750 11870 -4750 {lab=top}
N 11870 -4750 11980 -4750 {lab=top}
N 11650 -4690 11760 -4690 {lab=bot16c}
N 11760 -4690 11870 -4690 {lab=bot16c}
N 11870 -4690 11980 -4690 {lab=bot16c}
N 11190 -4750 11300 -4750 {lab=top}
N 11300 -4750 11410 -4750 {lab=top}
N 11410 -4750 11520 -4750 {lab=top}
N 11190 -4690 11300 -4690 {lab=bot16c}
N 11300 -4690 11410 -4690 {lab=bot16c}
N 11410 -4690 11520 -4690 {lab=bot16c}
N 11520 -4750 11650 -4750 {lab=top}
N 11520 -4690 11650 -4690 {lab=bot16c}
N 11980 -4750 12070 -4750 {lab=top}
N 11980 -4690 12070 -4690 {lab=bot16c}
N 12030 -4690 12030 -4660 {lab=bot16c}
N 12030 -4790 13430 -4790 {lab=top}
N 12030 -4790 12030 -4750 {lab=top}
N 10670 -4750 10780 -4750 {lab=top}
N 10780 -4750 10890 -4750 {lab=top}
N 10890 -4750 11000 -4750 {lab=top}
N 10670 -4690 10780 -4690 {lab=bot32c}
N 10780 -4690 10890 -4690 {lab=bot32c}
N 10890 -4690 11000 -4690 {lab=bot32c}
N 10210 -4750 10320 -4750 {lab=top}
N 10320 -4750 10430 -4750 {lab=top}
N 10430 -4750 10540 -4750 {lab=top}
N 10210 -4690 10320 -4690 {lab=bot32c}
N 10320 -4690 10430 -4690 {lab=bot32c}
N 10430 -4690 10540 -4690 {lab=bot32c}
N 10540 -4750 10670 -4750 {lab=top}
N 10540 -4690 10670 -4690 {lab=bot32c}
N 9790 -4750 9900 -4750 {lab=top}
N 9900 -4750 10010 -4750 {lab=top}
N 10010 -4750 10120 -4750 {lab=top}
N 9790 -4690 9900 -4690 {lab=bot32c}
N 9900 -4690 10010 -4690 {lab=bot32c}
N 10010 -4690 10120 -4690 {lab=bot32c}
N 9330 -4750 9440 -4750 {lab=top}
N 9440 -4750 9550 -4750 {lab=top}
N 9550 -4750 9660 -4750 {lab=top}
N 9330 -4690 9440 -4690 {lab=bot32c}
N 9440 -4690 9550 -4690 {lab=bot32c}
N 9550 -4690 9660 -4690 {lab=bot32c}
N 9660 -4750 9790 -4750 {lab=top}
N 9660 -4690 9790 -4690 {lab=bot32c}
N 10120 -4750 10210 -4750 {lab=top}
N 10120 -4690 10210 -4690 {lab=bot32c}
N 8870 -4750 8980 -4750 {lab=top}
N 8980 -4750 9090 -4750 {lab=top}
N 9090 -4750 9200 -4750 {lab=top}
N 8870 -4690 8980 -4690 {lab=bot32c}
N 8980 -4690 9090 -4690 {lab=bot32c}
N 9090 -4690 9200 -4690 {lab=bot32c}
N 8410 -4750 8520 -4750 {lab=top}
N 8520 -4750 8630 -4750 {lab=top}
N 8630 -4750 8740 -4750 {lab=top}
N 8410 -4690 8520 -4690 {lab=bot32c}
N 8520 -4690 8630 -4690 {lab=bot32c}
N 8630 -4690 8740 -4690 {lab=bot32c}
N 8740 -4750 8870 -4750 {lab=top}
N 8740 -4690 8870 -4690 {lab=bot32c}
N 7990 -4750 8100 -4750 {lab=top}
N 8100 -4750 8210 -4750 {lab=top}
N 8210 -4750 8320 -4750 {lab=top}
N 7990 -4690 8100 -4690 {lab=bot32c}
N 8100 -4690 8210 -4690 {lab=bot32c}
N 8210 -4690 8320 -4690 {lab=bot32c}
N 7530 -4750 7640 -4750 {lab=top}
N 7640 -4750 7750 -4750 {lab=top}
N 7750 -4750 7860 -4750 {lab=top}
N 7530 -4690 7640 -4690 {lab=bot32c}
N 7640 -4690 7750 -4690 {lab=bot32c}
N 7750 -4690 7860 -4690 {lab=bot32c}
N 7860 -4750 7990 -4750 {lab=top}
N 7860 -4690 7990 -4690 {lab=bot32c}
N 8320 -4750 8410 -4750 {lab=top}
N 8320 -4690 8410 -4690 {lab=bot32c}
N 9200 -4750 9330 -4750 {lab=top}
N 9200 -4690 9330 -4690 {lab=bot32c}
N 9260 -4690 9260 -4650 {lab=bot32c}
N 9260 -4790 12030 -4790 {lab=top}
N 9260 -4790 9260 -4750 {lab=top}
N 7010 -4750 7120 -4750 {lab=top}
N 7120 -4750 7230 -4750 {lab=top}
N 7230 -4750 7340 -4750 {lab=top}
N 7010 -4690 7120 -4690 {lab=bot64c}
N 7120 -4690 7230 -4690 {lab=bot64c}
N 7230 -4690 7340 -4690 {lab=bot64c}
N 6550 -4750 6660 -4750 {lab=top}
N 6660 -4750 6770 -4750 {lab=top}
N 6770 -4750 6880 -4750 {lab=top}
N 6550 -4690 6660 -4690 {lab=bot64c}
N 6660 -4690 6770 -4690 {lab=bot64c}
N 6770 -4690 6880 -4690 {lab=bot64c}
N 6880 -4750 7010 -4750 {lab=top}
N 6880 -4690 7010 -4690 {lab=bot64c}
N 6130 -4750 6240 -4750 {lab=top}
N 6240 -4750 6350 -4750 {lab=top}
N 6350 -4750 6460 -4750 {lab=top}
N 6130 -4690 6240 -4690 {lab=bot64c}
N 6240 -4690 6350 -4690 {lab=bot64c}
N 6350 -4690 6460 -4690 {lab=bot64c}
N 5670 -4750 5780 -4750 {lab=top}
N 5780 -4750 5890 -4750 {lab=top}
N 5890 -4750 6000 -4750 {lab=top}
N 5670 -4690 5780 -4690 {lab=bot64c}
N 5780 -4690 5890 -4690 {lab=bot64c}
N 5890 -4690 6000 -4690 {lab=bot64c}
N 6000 -4750 6130 -4750 {lab=top}
N 6000 -4690 6130 -4690 {lab=bot64c}
N 6460 -4750 6550 -4750 {lab=top}
N 6460 -4690 6550 -4690 {lab=bot64c}
N 5210 -4750 5320 -4750 {lab=top}
N 5320 -4750 5430 -4750 {lab=top}
N 5430 -4750 5540 -4750 {lab=top}
N 5210 -4690 5320 -4690 {lab=bot64c}
N 5320 -4690 5430 -4690 {lab=bot64c}
N 5430 -4690 5540 -4690 {lab=bot64c}
N 4750 -4750 4860 -4750 {lab=top}
N 4860 -4750 4970 -4750 {lab=top}
N 4970 -4750 5080 -4750 {lab=top}
N 4750 -4690 4860 -4690 {lab=bot64c}
N 4860 -4690 4970 -4690 {lab=bot64c}
N 4970 -4690 5080 -4690 {lab=bot64c}
N 5080 -4750 5210 -4750 {lab=top}
N 5080 -4690 5210 -4690 {lab=bot64c}
N 4330 -4750 4440 -4750 {lab=top}
N 4440 -4750 4550 -4750 {lab=top}
N 4550 -4750 4660 -4750 {lab=top}
N 4330 -4690 4440 -4690 {lab=bot64c}
N 4440 -4690 4550 -4690 {lab=bot64c}
N 4550 -4690 4660 -4690 {lab=bot64c}
N 3870 -4750 3980 -4750 {lab=top}
N 3980 -4750 4090 -4750 {lab=top}
N 4090 -4750 4200 -4750 {lab=top}
N 3870 -4690 3980 -4690 {lab=bot64c}
N 3980 -4690 4090 -4690 {lab=bot64c}
N 4090 -4690 4200 -4690 {lab=bot64c}
N 4200 -4750 4330 -4750 {lab=top}
N 4200 -4690 4330 -4690 {lab=bot64c}
N 4660 -4750 4750 -4750 {lab=top}
N 4660 -4690 4750 -4690 {lab=bot64c}
N 5540 -4750 5670 -4750 {lab=top}
N 5540 -4690 5670 -4690 {lab=bot64c}
N 5600 -4790 8370 -4790 {lab=top}
N 3400 -4750 3510 -4750 {lab=top}
N 3510 -4750 3620 -4750 {lab=top}
N 3620 -4750 3730 -4750 {lab=top}
N 3400 -4690 3510 -4690 {lab=bot64c}
N 3510 -4690 3620 -4690 {lab=bot64c}
N 3620 -4690 3730 -4690 {lab=bot64c}
N 2940 -4750 3050 -4750 {lab=top}
N 3050 -4750 3160 -4750 {lab=top}
N 3160 -4750 3270 -4750 {lab=top}
N 2940 -4690 3050 -4690 {lab=bot64c}
N 3050 -4690 3160 -4690 {lab=bot64c}
N 3160 -4690 3270 -4690 {lab=bot64c}
N 3270 -4750 3400 -4750 {lab=top}
N 3270 -4690 3400 -4690 {lab=bot64c}
N 2520 -4750 2630 -4750 {lab=top}
N 2630 -4750 2740 -4750 {lab=top}
N 2740 -4750 2850 -4750 {lab=top}
N 2520 -4690 2630 -4690 {lab=bot64c}
N 2630 -4690 2740 -4690 {lab=bot64c}
N 2740 -4690 2850 -4690 {lab=bot64c}
N 2060 -4750 2170 -4750 {lab=top}
N 2170 -4750 2280 -4750 {lab=top}
N 2280 -4750 2390 -4750 {lab=top}
N 2060 -4690 2170 -4690 {lab=bot64c}
N 2170 -4690 2280 -4690 {lab=bot64c}
N 2280 -4690 2390 -4690 {lab=bot64c}
N 2390 -4750 2520 -4750 {lab=top}
N 2390 -4690 2520 -4690 {lab=bot64c}
N 2850 -4750 2940 -4750 {lab=top}
N 2850 -4690 2940 -4690 {lab=bot64c}
N 1600 -4750 1710 -4750 {lab=top}
N 1710 -4750 1820 -4750 {lab=top}
N 1820 -4750 1930 -4750 {lab=top}
N 1600 -4690 1710 -4690 {lab=bot64c}
N 1710 -4690 1820 -4690 {lab=bot64c}
N 1820 -4690 1930 -4690 {lab=bot64c}
N 1140 -4750 1250 -4750 {lab=top}
N 1250 -4750 1360 -4750 {lab=top}
N 1360 -4750 1470 -4750 {lab=top}
N 1140 -4690 1250 -4690 {lab=bot64c}
N 1250 -4690 1360 -4690 {lab=bot64c}
N 1360 -4690 1470 -4690 {lab=bot64c}
N 1470 -4750 1600 -4750 {lab=top}
N 1470 -4690 1600 -4690 {lab=bot64c}
N 720 -4750 830 -4750 {lab=top}
N 830 -4750 940 -4750 {lab=top}
N 940 -4750 1050 -4750 {lab=top}
N 720 -4690 830 -4690 {lab=bot64c}
N 830 -4690 940 -4690 {lab=bot64c}
N 940 -4690 1050 -4690 {lab=bot64c}
N 260 -4750 370 -4750 {lab=top}
N 370 -4750 480 -4750 {lab=top}
N 480 -4750 590 -4750 {lab=top}
N 260 -4690 370 -4690 {lab=bot64c}
N 370 -4690 480 -4690 {lab=bot64c}
N 480 -4690 590 -4690 {lab=bot64c}
N 590 -4750 720 -4750 {lab=top}
N 590 -4690 720 -4690 {lab=bot64c}
N 1050 -4750 1140 -4750 {lab=top}
N 1050 -4690 1140 -4690 {lab=bot64c}
N 1930 -4750 2060 -4750 {lab=top}
N 1930 -4690 2060 -4690 {lab=bot64c}
N 3730 -4750 3870 -4750 {lab=top}
N 3730 -4690 3870 -4690 {lab=bot64c}
N 3800 -4690 3800 -4670 {lab=bot64c}
N 4760 -4790 5600 -4790 {lab=top}
N 8370 -4790 9260 -4790 {lab=top}
N 3800 -4790 3800 -4750 {lab=top}
N 3800 -4790 4760 -4790 {lab=top}
N -220 -4750 -110 -4750 {lab=top}
N -110 -4750 0 -4750 {lab=top}
N 0 -4750 110 -4750 {lab=top}
N -220 -4690 -110 -4690 {lab=bot128c}
N -110 -4690 0 -4690 {lab=bot128c}
N 0 -4690 110 -4690 {lab=bot128c}
N -680 -4750 -570 -4750 {lab=top}
N -570 -4750 -460 -4750 {lab=top}
N -460 -4750 -350 -4750 {lab=top}
N -680 -4690 -570 -4690 {lab=bot128c}
N -570 -4690 -460 -4690 {lab=bot128c}
N -460 -4690 -350 -4690 {lab=bot128c}
N -350 -4750 -220 -4750 {lab=top}
N -350 -4690 -220 -4690 {lab=bot128c}
N -1100 -4750 -990 -4750 {lab=top}
N -990 -4750 -880 -4750 {lab=top}
N -880 -4750 -770 -4750 {lab=top}
N -1100 -4690 -990 -4690 {lab=bot128c}
N -990 -4690 -880 -4690 {lab=bot128c}
N -880 -4690 -770 -4690 {lab=bot128c}
N -1560 -4750 -1450 -4750 {lab=top}
N -1450 -4750 -1340 -4750 {lab=top}
N -1340 -4750 -1230 -4750 {lab=top}
N -1560 -4690 -1450 -4690 {lab=bot128c}
N -1450 -4690 -1340 -4690 {lab=bot128c}
N -1340 -4690 -1230 -4690 {lab=bot128c}
N -1230 -4750 -1100 -4750 {lab=top}
N -1230 -4690 -1100 -4690 {lab=bot128c}
N -770 -4750 -680 -4750 {lab=top}
N -770 -4690 -680 -4690 {lab=bot128c}
N -2020 -4750 -1910 -4750 {lab=top}
N -1910 -4750 -1800 -4750 {lab=top}
N -1800 -4750 -1690 -4750 {lab=top}
N -2020 -4690 -1910 -4690 {lab=bot128c}
N -1910 -4690 -1800 -4690 {lab=bot128c}
N -1800 -4690 -1690 -4690 {lab=bot128c}
N -2480 -4750 -2370 -4750 {lab=top}
N -2370 -4750 -2260 -4750 {lab=top}
N -2260 -4750 -2150 -4750 {lab=top}
N -2480 -4690 -2370 -4690 {lab=bot128c}
N -2370 -4690 -2260 -4690 {lab=bot128c}
N -2260 -4690 -2150 -4690 {lab=bot128c}
N -2150 -4750 -2020 -4750 {lab=top}
N -2150 -4690 -2020 -4690 {lab=bot128c}
N -2900 -4750 -2790 -4750 {lab=top}
N -2790 -4750 -2680 -4750 {lab=top}
N -2680 -4750 -2570 -4750 {lab=top}
N -2900 -4690 -2790 -4690 {lab=bot128c}
N -2790 -4690 -2680 -4690 {lab=bot128c}
N -2680 -4690 -2570 -4690 {lab=bot128c}
N -3360 -4750 -3250 -4750 {lab=top}
N -3250 -4750 -3140 -4750 {lab=top}
N -3140 -4750 -3030 -4750 {lab=top}
N -3360 -4690 -3250 -4690 {lab=bot128c}
N -3250 -4690 -3140 -4690 {lab=bot128c}
N -3140 -4690 -3030 -4690 {lab=bot128c}
N -3030 -4750 -2900 -4750 {lab=top}
N -3030 -4690 -2900 -4690 {lab=bot128c}
N -2570 -4750 -2480 -4750 {lab=top}
N -2570 -4690 -2480 -4690 {lab=bot128c}
N -1690 -4750 -1560 -4750 {lab=top}
N -1690 -4690 -1560 -4690 {lab=bot128c}
N -1630 -4790 1140 -4790 {lab=top}
N -3830 -4750 -3720 -4750 {lab=top}
N -3720 -4750 -3610 -4750 {lab=top}
N -3610 -4750 -3500 -4750 {lab=top}
N -3830 -4690 -3720 -4690 {lab=bot128c}
N -3720 -4690 -3610 -4690 {lab=bot128c}
N -3610 -4690 -3500 -4690 {lab=bot128c}
N -4290 -4750 -4180 -4750 {lab=top}
N -4180 -4750 -4070 -4750 {lab=top}
N -4070 -4750 -3960 -4750 {lab=top}
N -4290 -4690 -4180 -4690 {lab=bot128c}
N -4180 -4690 -4070 -4690 {lab=bot128c}
N -4070 -4690 -3960 -4690 {lab=bot128c}
N -3960 -4750 -3830 -4750 {lab=top}
N -3960 -4690 -3830 -4690 {lab=bot128c}
N -4710 -4750 -4600 -4750 {lab=top}
N -4600 -4750 -4490 -4750 {lab=top}
N -4490 -4750 -4380 -4750 {lab=top}
N -4710 -4690 -4600 -4690 {lab=bot128c}
N -4600 -4690 -4490 -4690 {lab=bot128c}
N -4490 -4690 -4380 -4690 {lab=bot128c}
N -5170 -4750 -5060 -4750 {lab=top}
N -5060 -4750 -4950 -4750 {lab=top}
N -4950 -4750 -4840 -4750 {lab=top}
N -5170 -4690 -5060 -4690 {lab=bot128c}
N -5060 -4690 -4950 -4690 {lab=bot128c}
N -4950 -4690 -4840 -4690 {lab=bot128c}
N -4840 -4750 -4710 -4750 {lab=top}
N -4840 -4690 -4710 -4690 {lab=bot128c}
N -4380 -4750 -4290 -4750 {lab=top}
N -4380 -4690 -4290 -4690 {lab=bot128c}
N -5630 -4750 -5520 -4750 {lab=top}
N -5520 -4750 -5410 -4750 {lab=top}
N -5410 -4750 -5300 -4750 {lab=top}
N -5630 -4690 -5520 -4690 {lab=bot128c}
N -5520 -4690 -5410 -4690 {lab=bot128c}
N -5410 -4690 -5300 -4690 {lab=bot128c}
N -6090 -4750 -5980 -4750 {lab=top}
N -5980 -4750 -5870 -4750 {lab=top}
N -5870 -4750 -5760 -4750 {lab=top}
N -6090 -4690 -5980 -4690 {lab=bot128c}
N -5980 -4690 -5870 -4690 {lab=bot128c}
N -5870 -4690 -5760 -4690 {lab=bot128c}
N -5760 -4750 -5630 -4750 {lab=top}
N -5760 -4690 -5630 -4690 {lab=bot128c}
N -6510 -4750 -6400 -4750 {lab=top}
N -6400 -4750 -6290 -4750 {lab=top}
N -6290 -4750 -6180 -4750 {lab=top}
N -6510 -4690 -6400 -4690 {lab=bot128c}
N -6400 -4690 -6290 -4690 {lab=bot128c}
N -6290 -4690 -6180 -4690 {lab=bot128c}
N -6970 -4750 -6860 -4750 {lab=top}
N -6860 -4750 -6750 -4750 {lab=top}
N -6750 -4750 -6640 -4750 {lab=top}
N -6970 -4690 -6860 -4690 {lab=bot128c}
N -6860 -4690 -6750 -4690 {lab=bot128c}
N -6750 -4690 -6640 -4690 {lab=bot128c}
N -6640 -4750 -6510 -4750 {lab=top}
N -6640 -4690 -6510 -4690 {lab=bot128c}
N -6180 -4750 -6090 -4750 {lab=top}
N -6180 -4690 -6090 -4690 {lab=bot128c}
N -5300 -4750 -5170 -4750 {lab=top}
N -5300 -4690 -5170 -4690 {lab=bot128c}
N -3500 -4750 -3360 -4750 {lab=top}
N -3500 -4690 -3360 -4690 {lab=bot128c}
N -2470 -4790 -1630 -4790 {lab=top}
N -3430 -4790 -2470 -4790 {lab=top}
N -7420 -4750 -7310 -4750 {lab=top}
N -7310 -4750 -7200 -4750 {lab=top}
N -7200 -4750 -7090 -4750 {lab=top}
N -7420 -4690 -7310 -4690 {lab=bot128c}
N -7310 -4690 -7200 -4690 {lab=bot128c}
N -7200 -4690 -7090 -4690 {lab=bot128c}
N -7880 -4750 -7770 -4750 {lab=top}
N -7770 -4750 -7660 -4750 {lab=top}
N -7660 -4750 -7550 -4750 {lab=top}
N -7880 -4690 -7770 -4690 {lab=bot128c}
N -7770 -4690 -7660 -4690 {lab=bot128c}
N -7660 -4690 -7550 -4690 {lab=bot128c}
N -7550 -4750 -7420 -4750 {lab=top}
N -7550 -4690 -7420 -4690 {lab=bot128c}
N -8300 -4750 -8190 -4750 {lab=top}
N -8190 -4750 -8080 -4750 {lab=top}
N -8080 -4750 -7970 -4750 {lab=top}
N -8300 -4690 -8190 -4690 {lab=bot128c}
N -8190 -4690 -8080 -4690 {lab=bot128c}
N -8080 -4690 -7970 -4690 {lab=bot128c}
N -8760 -4750 -8650 -4750 {lab=top}
N -8650 -4750 -8540 -4750 {lab=top}
N -8540 -4750 -8430 -4750 {lab=top}
N -8760 -4690 -8650 -4690 {lab=bot128c}
N -8650 -4690 -8540 -4690 {lab=bot128c}
N -8540 -4690 -8430 -4690 {lab=bot128c}
N -8430 -4750 -8300 -4750 {lab=top}
N -8430 -4690 -8300 -4690 {lab=bot128c}
N -7970 -4750 -7880 -4750 {lab=top}
N -7970 -4690 -7880 -4690 {lab=bot128c}
N -9220 -4750 -9110 -4750 {lab=top}
N -9110 -4750 -9000 -4750 {lab=top}
N -9000 -4750 -8890 -4750 {lab=top}
N -9220 -4690 -9110 -4690 {lab=bot128c}
N -9110 -4690 -9000 -4690 {lab=bot128c}
N -9000 -4690 -8890 -4690 {lab=bot128c}
N -9680 -4750 -9570 -4750 {lab=top}
N -9570 -4750 -9460 -4750 {lab=top}
N -9460 -4750 -9350 -4750 {lab=top}
N -9680 -4690 -9570 -4690 {lab=bot128c}
N -9570 -4690 -9460 -4690 {lab=bot128c}
N -9460 -4690 -9350 -4690 {lab=bot128c}
N -9350 -4750 -9220 -4750 {lab=top}
N -9350 -4690 -9220 -4690 {lab=bot128c}
N -10100 -4750 -9990 -4750 {lab=top}
N -9990 -4750 -9880 -4750 {lab=top}
N -9880 -4750 -9770 -4750 {lab=top}
N -10100 -4690 -9990 -4690 {lab=bot128c}
N -9990 -4690 -9880 -4690 {lab=bot128c}
N -9880 -4690 -9770 -4690 {lab=bot128c}
N -10560 -4750 -10450 -4750 {lab=top}
N -10450 -4750 -10340 -4750 {lab=top}
N -10340 -4750 -10230 -4750 {lab=top}
N -10560 -4690 -10450 -4690 {lab=bot128c}
N -10450 -4690 -10340 -4690 {lab=bot128c}
N -10340 -4690 -10230 -4690 {lab=bot128c}
N -10230 -4750 -10100 -4750 {lab=top}
N -10230 -4690 -10100 -4690 {lab=bot128c}
N -9770 -4750 -9680 -4750 {lab=top}
N -9770 -4690 -9680 -4690 {lab=bot128c}
N -8890 -4750 -8760 -4750 {lab=top}
N -8890 -4690 -8760 -4690 {lab=bot128c}
N -11030 -4750 -10920 -4750 {lab=top}
N -10920 -4750 -10810 -4750 {lab=top}
N -10810 -4750 -10700 -4750 {lab=top}
N -11030 -4690 -10920 -4690 {lab=bot128c}
N -10920 -4690 -10810 -4690 {lab=bot128c}
N -10810 -4690 -10700 -4690 {lab=bot128c}
N -11490 -4750 -11380 -4750 {lab=top}
N -11380 -4750 -11270 -4750 {lab=top}
N -11270 -4750 -11160 -4750 {lab=top}
N -11490 -4690 -11380 -4690 {lab=bot128c}
N -11380 -4690 -11270 -4690 {lab=bot128c}
N -11270 -4690 -11160 -4690 {lab=bot128c}
N -11160 -4750 -11030 -4750 {lab=top}
N -11160 -4690 -11030 -4690 {lab=bot128c}
N -11910 -4750 -11800 -4750 {lab=top}
N -11800 -4750 -11690 -4750 {lab=top}
N -11690 -4750 -11580 -4750 {lab=top}
N -11910 -4690 -11800 -4690 {lab=bot128c}
N -11800 -4690 -11690 -4690 {lab=bot128c}
N -11690 -4690 -11580 -4690 {lab=bot128c}
N -12370 -4750 -12260 -4750 {lab=top}
N -12260 -4750 -12150 -4750 {lab=top}
N -12150 -4750 -12040 -4750 {lab=top}
N -12370 -4690 -12260 -4690 {lab=bot128c}
N -12260 -4690 -12150 -4690 {lab=bot128c}
N -12150 -4690 -12040 -4690 {lab=bot128c}
N -12040 -4750 -11910 -4750 {lab=top}
N -12040 -4690 -11910 -4690 {lab=bot128c}
N -11580 -4750 -11490 -4750 {lab=top}
N -11580 -4690 -11490 -4690 {lab=bot128c}
N -12830 -4750 -12720 -4750 {lab=top}
N -12720 -4750 -12610 -4750 {lab=top}
N -12610 -4750 -12500 -4750 {lab=top}
N -12830 -4690 -12720 -4690 {lab=bot128c}
N -12720 -4690 -12610 -4690 {lab=bot128c}
N -12610 -4690 -12500 -4690 {lab=bot128c}
N -13290 -4750 -13180 -4750 {lab=top}
N -13180 -4750 -13070 -4750 {lab=top}
N -13070 -4750 -12960 -4750 {lab=top}
N -13290 -4690 -13180 -4690 {lab=bot128c}
N -13180 -4690 -13070 -4690 {lab=bot128c}
N -13070 -4690 -12960 -4690 {lab=bot128c}
N -12960 -4750 -12830 -4750 {lab=top}
N -12960 -4690 -12830 -4690 {lab=bot128c}
N -13710 -4750 -13600 -4750 {lab=top}
N -13600 -4750 -13490 -4750 {lab=top}
N -13490 -4750 -13380 -4750 {lab=top}
N -13710 -4690 -13600 -4690 {lab=bot128c}
N -13600 -4690 -13490 -4690 {lab=bot128c}
N -13490 -4690 -13380 -4690 {lab=bot128c}
N -14170 -4750 -14060 -4750 {lab=top}
N -14060 -4750 -13950 -4750 {lab=top}
N -13950 -4750 -13840 -4750 {lab=top}
N -14170 -4690 -14060 -4690 {lab=bot128c}
N -14060 -4690 -13950 -4690 {lab=bot128c}
N -13950 -4690 -13840 -4690 {lab=bot128c}
N -13840 -4750 -13710 -4750 {lab=top}
N -13840 -4690 -13710 -4690 {lab=bot128c}
N -13380 -4750 -13290 -4750 {lab=top}
N -13380 -4690 -13290 -4690 {lab=bot128c}
N -12500 -4750 -12370 -4750 {lab=top}
N -12500 -4690 -12370 -4690 {lab=bot128c}
N -10700 -4750 -10560 -4750 {lab=top}
N -10700 -4690 -10560 -4690 {lab=bot128c}
N 1140 -4790 3800 -4790 {lab=top}
N -6070 -4790 -3430 -4790 {lab=top}
N -7090 -4750 -6970 -4750 {lab=top}
N -7090 -4690 -6970 -4690 {lab=bot128c}
N -7030 -4790 -7030 -4750 {lab=top}
N -7030 -4690 -7030 -4670 {lab=bot128c}
N -7030 -4790 -6070 -4790 {lab=top}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14020 -4720 0 0 {name=C1 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14130 -4720 0 0 {name=C2 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14240 -4720 0 0 {name=C3 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14350 -4720 0 0 {name=C4 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14510 -4720 0 0 {name=C5 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14620 -4720 0 0 {name=C6 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14790 -4720 0 0 {name=C7 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14960 -4720 0 0 {name=C8 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 680 -790 0 0 {name=M1
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1800 -780 0 0 {name=M2
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 700 -760 0 0 {name=l6 lab=0}
C {lab_pin.sym} 660 -790 3 0 {name=p6 sig_type=std_logic lab=gndb2}
C {lab_pin.sym} 1780 -780 1 0 {name=p7 sig_type=std_logic lab=~out2}
C {sky130_fd_pr/nfet_01v8.sym} 2110 -780 0 0 {name=M3
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2300 -780 2 0 {name=M4
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2200 -810 1 0 {name=p8 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2200 -730 2 0 {name=p9 sig_type=std_logic lab=bot4c}
C {lab_pin.sym} 1820 -730 2 0 {name=p10 sig_type=std_logic lab=bot4c}
C {lab_pin.sym} 700 -820 1 0 {name=p11 sig_type=std_logic lab=bot4c}
C {gnd.sym} 2180 -780 0 0 {name=l7 lab=0}
C {vsource.sym} 1170 -3920 0 0 {name=V3 value=1.8 savecurrent=false}
C {lab_pin.sym} 1170 -3950 1 0 {name=p12 sig_type=std_logic lab=vdd}
C {gnd.sym} 1170 -3890 0 0 {name=l5 lab=0}
C {lab_pin.sym} 2260 -780 0 0 {name=p5 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 14180 -4660 0 0 {name=p20 sig_type=std_logic lab=bot4c}
C {lab_pin.sym} 1820 -830 2 0 {name=p21 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2070 -780 0 0 {name=p23 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2330 -780 2 0 {name=p13 sig_type=std_logic lab=~clock}
C {lab_pin.sym} 14560 -4660 0 0 {name=p28 sig_type=std_logic lab=bot2c}
C {lab_pin.sym} 14790 -4690 3 0 {name=p36 sig_type=std_logic lab=bot1c}
C {sky130_fd_pr/nfet_01v8.sym} 270 730 0 0 {name=M15
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 330 730 0 0 {name=l15 lab=0}
C {gnd.sym} 290 760 0 0 {name=l16 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 510 720 0 0 {name=M17
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 700 720 2 0 {name=M18
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 600 690 1 0 {name=p49 sig_type=std_logic lab=vin}
C {gnd.sym} 580 720 0 0 {name=l17 lab=0}
C {lab_pin.sym} 660 720 0 0 {name=p51 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 470 720 0 0 {name=p54 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 730 720 2 0 {name=p55 sig_type=std_logic lab=~clock}
C {lab_pin.sym} 250 730 3 0 {name=p52 sig_type=std_logic lab=~clock}
C {lab_pin.sym} 600 770 2 0 {name=p53 sig_type=std_logic lab=dum}
C {lab_pin.sym} 290 700 1 0 {name=p56 sig_type=std_logic lab=dum}
C {lab_pin.sym} 14960 -4690 3 0 {name=p57 sig_type=std_logic lab=dum}
C {lab_pin.sym} 14580 -4850 2 0 {name=p16 sig_type=std_logic lab=top}
C {vsource.sym} 370 -4020 1 0 {name=Vcm value=0.9 savecurrent=false}
C {sky130_fd_pr/pfet_01v8.sym} 420 -3950 0 0 {name=M16
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 440 -3920 3 0 {name=p50 sig_type=std_logic lab=top}
C {gnd.sym} 340 -4000 0 0 {name=l10 lab=0}
C {lab_pin.sym} 400 -3950 0 0 {name=p15 sig_type=std_logic lab=~clock
}
C {lab_pin.sym} 480 -3950 2 0 {name=p17 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 380 -660 0 0 {name=M5
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 530 -660 0 1 {name=M6
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 430 -830 0 0 {name=M19
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 430 -750 0 0 {name=M20
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 450 -860 1 0 {name=p18 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 320 -830 0 0 {name=p19 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 400 -750 0 0 {name=p22 sig_type=std_logic lab=b2}
C {gnd.sym} 450 -610 0 0 {name=l4 lab=0}
C {lab_pin.sym} 550 -660 2 0 {name=p29 sig_type=std_logic lab=b2}
C {lab_pin.sym} 480 -710 2 0 {name=p39 sig_type=std_logic lab=gndb2}
C {sky130_fd_pr/nfet_01v8.sym} 1310 -660 0 0 {name=M21
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1460 -660 0 1 {name=M22
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1360 -830 0 0 {name=M23
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1360 -750 0 0 {name=M24
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1380 -860 1 0 {name=p58 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1250 -830 0 0 {name=p59 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1330 -750 0 0 {name=p60 sig_type=std_logic lab=~b2}
C {gnd.sym} 1380 -610 0 0 {name=l8 lab=0}
C {lab_pin.sym} 1480 -660 2 0 {name=p61 sig_type=std_logic lab=~b2}
C {lab_pin.sym} 1410 -710 2 0 {name=p62 sig_type=std_logic lab=out2}
C {sky130_fd_pr/nfet_01v8.sym} 1090 -710 0 0 {name=n1
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1090 -800 0 0 {name=p63
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1110 -660 0 0 {name=l14 lab=0}
C {lab_pin.sym} 1110 -830 0 0 {name=p64 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1010 -760 0 0 {name=p65 sig_type=std_logic lab=b2
}
C {lab_pin.sym} 1120 -750 2 0 {name=p66 sig_type=std_logic lab=~b2}
C {sky130_fd_pr/nfet_01v8.sym} 1610 -720 0 0 {name=n3
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1610 -810 0 0 {name=p67
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1630 -670 0 0 {name=l18 lab=0}
C {lab_pin.sym} 1630 -840 0 0 {name=p68 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1530 -770 0 0 {name=p69 sig_type=std_logic lab=out2
}
C {lab_pin.sym} 1640 -760 2 0 {name=p70 sig_type=std_logic lab=~out2}
C {sky130_fd_pr/nfet_01v8.sym} 630 -250 0 0 {name=M7
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1750 -240 0 0 {name=M8
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 650 -220 0 0 {name=l1 lab=0}
C {lab_pin.sym} 610 -250 3 0 {name=p14 sig_type=std_logic lab=gndb1}
C {lab_pin.sym} 1730 -240 1 0 {name=p24 sig_type=std_logic lab=~out1}
C {sky130_fd_pr/nfet_01v8.sym} 2060 -240 0 0 {name=M9
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2250 -240 2 0 {name=M10
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2150 -270 1 0 {name=p25 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2150 -190 2 0 {name=p26 sig_type=std_logic lab=bot2c}
C {lab_pin.sym} 1770 -190 2 0 {name=p27 sig_type=std_logic lab=bot2c}
C {lab_pin.sym} 650 -280 1 0 {name=p30 sig_type=std_logic lab=bot2c}
C {gnd.sym} 2130 -240 0 0 {name=l3 lab=0}
C {lab_pin.sym} 2210 -240 0 0 {name=p32 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1770 -290 2 0 {name=p33 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2020 -240 0 0 {name=p34 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2280 -240 2 0 {name=p35 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 330 -120 0 0 {name=M25
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 480 -120 0 1 {name=M26
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 380 -290 0 0 {name=M27
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 380 -210 0 0 {name=M28
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 400 -320 1 0 {name=p71 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 270 -290 0 0 {name=p72 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 350 -210 0 0 {name=p73 sig_type=std_logic lab=b1}
C {gnd.sym} 400 -70 0 0 {name=l19 lab=0}
C {lab_pin.sym} 500 -120 2 0 {name=p74 sig_type=std_logic lab=b1}
C {lab_pin.sym} 430 -170 2 0 {name=p75 sig_type=std_logic lab=gndb1}
C {sky130_fd_pr/nfet_01v8.sym} 1260 -120 0 0 {name=M29
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1410 -120 0 1 {name=M30
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1310 -290 0 0 {name=M31
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1310 -210 0 0 {name=M32
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1330 -320 1 0 {name=p76 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1200 -290 0 0 {name=p77 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1280 -210 0 0 {name=p78 sig_type=std_logic lab=~b1}
C {gnd.sym} 1330 -70 0 0 {name=l20 lab=0}
C {lab_pin.sym} 1430 -120 2 0 {name=p79 sig_type=std_logic lab=~b1}
C {lab_pin.sym} 1360 -170 2 0 {name=p80 sig_type=std_logic lab=out1}
C {sky130_fd_pr/nfet_01v8.sym} 1040 -170 0 0 {name=n4
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1040 -260 0 0 {name=p81
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1060 -120 0 0 {name=l21 lab=0}
C {lab_pin.sym} 1060 -290 0 0 {name=p82 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 960 -220 0 0 {name=p83 sig_type=std_logic lab=b1
}
C {lab_pin.sym} 1070 -210 2 0 {name=p84 sig_type=std_logic lab=~b1}
C {sky130_fd_pr/nfet_01v8.sym} 1560 -180 0 0 {name=n5
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1560 -270 0 0 {name=p85
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1580 -130 0 0 {name=l22 lab=0}
C {lab_pin.sym} 1580 -300 0 0 {name=p86 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1480 -230 0 0 {name=p87 sig_type=std_logic lab=out1
}
C {lab_pin.sym} 1590 -220 2 0 {name=p88 sig_type=std_logic lab=~out1}
C {sky130_fd_pr/nfet_01v8.sym} 640 260 0 0 {name=M11
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1760 270 0 0 {name=M12
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 660 290 0 0 {name=l9 lab=0}
C {lab_pin.sym} 620 260 3 0 {name=p31 sig_type=std_logic lab=gndb0}
C {lab_pin.sym} 1740 270 1 0 {name=p37 sig_type=std_logic lab=~out0}
C {sky130_fd_pr/nfet_01v8.sym} 2070 270 0 0 {name=M13
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2260 270 2 0 {name=M14
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2160 240 1 0 {name=p38 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2160 320 2 0 {name=p40 sig_type=std_logic lab=bot1c}
C {lab_pin.sym} 1780 320 2 0 {name=p41 sig_type=std_logic lab=bot1c}
C {lab_pin.sym} 660 230 1 0 {name=p42 sig_type=std_logic lab=bot1c}
C {gnd.sym} 2140 270 0 0 {name=l11 lab=0}
C {lab_pin.sym} 2220 270 0 0 {name=p43 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1780 220 2 0 {name=p44 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2030 270 0 0 {name=p45 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2290 270 2 0 {name=p46 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 340 390 0 0 {name=M33
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 490 390 0 1 {name=M34
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 390 220 0 0 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 390 300 0 0 {name=M36
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 410 190 1 0 {name=p47 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 280 220 0 0 {name=p48 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 360 300 0 0 {name=p89 sig_type=std_logic lab=b0}
C {gnd.sym} 410 440 0 0 {name=l12 lab=0}
C {lab_pin.sym} 510 390 2 0 {name=p90 sig_type=std_logic lab=b0}
C {lab_pin.sym} 440 340 2 0 {name=p91 sig_type=std_logic lab=gndb0}
C {sky130_fd_pr/nfet_01v8.sym} 1270 390 0 0 {name=M37
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1420 390 0 1 {name=M38
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1320 220 0 0 {name=M39
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1320 300 0 0 {name=M40
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1340 190 1 0 {name=p92 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1210 220 0 0 {name=p93 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1290 300 0 0 {name=p94 sig_type=std_logic lab=~b0}
C {gnd.sym} 1340 440 0 0 {name=l13 lab=0}
C {lab_pin.sym} 1440 390 2 0 {name=p95 sig_type=std_logic lab=~b0}
C {lab_pin.sym} 1370 340 2 0 {name=p96 sig_type=std_logic lab=out0}
C {sky130_fd_pr/nfet_01v8.sym} 1050 340 0 0 {name=n6
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1050 250 0 0 {name=p97
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1070 390 0 0 {name=l23 lab=0}
C {lab_pin.sym} 1070 220 0 0 {name=p98 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 970 290 0 0 {name=p99 sig_type=std_logic lab=b0
}
C {lab_pin.sym} 1080 300 2 0 {name=p100 sig_type=std_logic lab=~b0}
C {sky130_fd_pr/nfet_01v8.sym} 1570 330 0 0 {name=n7
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1570 240 0 0 {name=p101
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1590 380 0 0 {name=l24 lab=0}
C {lab_pin.sym} 1590 210 0 0 {name=p102 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1490 280 0 0 {name=p103 sig_type=std_logic lab=out0
}
C {lab_pin.sym} 1600 290 2 0 {name=p104 sig_type=std_logic lab=~out0}
C {sky130_fd_pr/nfet_01v8.sym} 860 -3920 0 0 {name=n8
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 860 -4010 0 0 {name=p105
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 880 -3870 0 0 {name=l25 lab=0}
C {lab_pin.sym} 880 -4040 0 0 {name=p106 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 780 -3970 0 0 {name=p107 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 890 -3960 2 0 {name=p108 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 670 -1350 0 0 {name=M41
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1790 -1340 0 0 {name=M42
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 690 -1320 0 0 {name=l2 lab=0}
C {lab_pin.sym} 650 -1350 3 0 {name=p1 sig_type=std_logic lab=gndb3}
C {lab_pin.sym} 1770 -1340 1 0 {name=p2 sig_type=std_logic lab=~out3}
C {sky130_fd_pr/nfet_01v8.sym} 2100 -1340 0 0 {name=M43
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2290 -1340 2 0 {name=M44
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2190 -1370 1 0 {name=p3 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2190 -1290 2 0 {name=p4 sig_type=std_logic lab=bot8c}
C {lab_pin.sym} 1810 -1290 2 0 {name=p109 sig_type=std_logic lab=bot8c}
C {lab_pin.sym} 690 -1380 1 0 {name=p110 sig_type=std_logic lab=bot8c}
C {gnd.sym} 2170 -1340 0 0 {name=l26 lab=0}
C {lab_pin.sym} 2250 -1340 0 0 {name=p111 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1810 -1390 2 0 {name=p112 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2060 -1340 0 0 {name=p113 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2320 -1340 2 0 {name=p114 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 370 -1220 0 0 {name=M45
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 520 -1220 0 1 {name=M46
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 420 -1390 0 0 {name=M47
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 420 -1310 0 0 {name=M48
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 440 -1420 1 0 {name=p115 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 310 -1390 0 0 {name=p116 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 390 -1310 0 0 {name=p117 sig_type=std_logic lab=b3}
C {gnd.sym} 440 -1170 0 0 {name=l27 lab=0}
C {lab_pin.sym} 540 -1220 2 0 {name=p118 sig_type=std_logic lab=b3}
C {lab_pin.sym} 470 -1270 2 0 {name=p119 sig_type=std_logic lab=gndb3}
C {sky130_fd_pr/nfet_01v8.sym} 1300 -1220 0 0 {name=M49
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1450 -1220 0 1 {name=M50
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1350 -1390 0 0 {name=M51
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1350 -1310 0 0 {name=M52
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1370 -1420 1 0 {name=p120 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1240 -1390 0 0 {name=p121 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1320 -1310 0 0 {name=p122 sig_type=std_logic lab=~b3}
C {gnd.sym} 1370 -1170 0 0 {name=l28 lab=0}
C {lab_pin.sym} 1470 -1220 2 0 {name=p123 sig_type=std_logic lab=~b3}
C {lab_pin.sym} 1400 -1270 2 0 {name=p124 sig_type=std_logic lab=out3}
C {sky130_fd_pr/nfet_01v8.sym} 1080 -1270 0 0 {name=n2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1080 -1360 0 0 {name=p125
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1100 -1220 0 0 {name=l29 lab=0}
C {lab_pin.sym} 1100 -1390 0 0 {name=p126 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1000 -1320 0 0 {name=p127 sig_type=std_logic lab=b3
}
C {lab_pin.sym} 1110 -1310 2 0 {name=p128 sig_type=std_logic lab=~b3}
C {sky130_fd_pr/nfet_01v8.sym} 1600 -1280 0 0 {name=n9
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1600 -1370 0 0 {name=p129
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1620 -1230 0 0 {name=l30 lab=0}
C {lab_pin.sym} 1620 -1400 0 0 {name=p130 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1520 -1330 0 0 {name=p131 sig_type=std_logic lab=out3
}
C {lab_pin.sym} 1630 -1320 2 0 {name=p132 sig_type=std_logic lab=~out3}
C {sky130_fd_pr/nfet_01v8.sym} 660 -1880 0 0 {name=M53
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1780 -1870 0 0 {name=M54
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 680 -1850 0 0 {name=l31 lab=0}
C {lab_pin.sym} 640 -1880 3 0 {name=p133 sig_type=std_logic lab=gndb4}
C {lab_pin.sym} 1760 -1870 1 0 {name=p134 sig_type=std_logic lab=~out4}
C {sky130_fd_pr/nfet_01v8.sym} 2090 -1870 0 0 {name=M55
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2280 -1870 2 0 {name=M56
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2180 -1900 1 0 {name=p135 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2180 -1820 2 0 {name=p136 sig_type=std_logic lab=bot16c}
C {lab_pin.sym} 1800 -1820 2 0 {name=p137 sig_type=std_logic lab=bot16c}
C {lab_pin.sym} 680 -1910 1 0 {name=p138 sig_type=std_logic lab=bot16c}
C {gnd.sym} 2160 -1870 0 0 {name=l32 lab=0}
C {lab_pin.sym} 2240 -1870 0 0 {name=p139 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1800 -1920 2 0 {name=p140 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2050 -1870 0 0 {name=p141 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2310 -1870 2 0 {name=p142 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 360 -1750 0 0 {name=M57
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 510 -1750 0 1 {name=M58
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -1920 0 0 {name=M59
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -1840 0 0 {name=M60
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 430 -1950 1 0 {name=p143 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 300 -1920 0 0 {name=p144 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 380 -1840 0 0 {name=p145 sig_type=std_logic lab=b4}
C {gnd.sym} 430 -1700 0 0 {name=l33 lab=0}
C {lab_pin.sym} 530 -1750 2 0 {name=p146 sig_type=std_logic lab=b4}
C {lab_pin.sym} 460 -1800 2 0 {name=p147 sig_type=std_logic lab=gndb4}
C {sky130_fd_pr/nfet_01v8.sym} 1290 -1750 0 0 {name=M61
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1440 -1750 0 1 {name=M62
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1340 -1920 0 0 {name=M63
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1340 -1840 0 0 {name=M64
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1360 -1950 1 0 {name=p148 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1230 -1920 0 0 {name=p149 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1310 -1840 0 0 {name=p150 sig_type=std_logic lab=~b4}
C {gnd.sym} 1360 -1700 0 0 {name=l34 lab=0}
C {lab_pin.sym} 1460 -1750 2 0 {name=p151 sig_type=std_logic lab=~b4}
C {lab_pin.sym} 1390 -1800 2 0 {name=p152 sig_type=std_logic lab=out4}
C {sky130_fd_pr/nfet_01v8.sym} 1070 -1800 0 0 {name=n10
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1070 -1890 0 0 {name=p153
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1090 -1750 0 0 {name=l35 lab=0}
C {lab_pin.sym} 1090 -1920 0 0 {name=p154 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 990 -1850 0 0 {name=p155 sig_type=std_logic lab=b4
}
C {lab_pin.sym} 1100 -1840 2 0 {name=p156 sig_type=std_logic lab=~b4}
C {sky130_fd_pr/nfet_01v8.sym} 1590 -1810 0 0 {name=n11
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1590 -1900 0 0 {name=p157
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1610 -1760 0 0 {name=l36 lab=0}
C {lab_pin.sym} 1610 -1930 0 0 {name=p158 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1510 -1860 0 0 {name=p159 sig_type=std_logic lab=out4
}
C {lab_pin.sym} 1620 -1850 2 0 {name=p160 sig_type=std_logic lab=~out4}
C {sky130_fd_pr/nfet_01v8.sym} 650 -2390 0 0 {name=M65
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1770 -2380 0 0 {name=M66
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 670 -2360 0 0 {name=l37 lab=0}
C {lab_pin.sym} 630 -2390 3 0 {name=p161 sig_type=std_logic lab=gndb5}
C {lab_pin.sym} 1750 -2380 1 0 {name=p162 sig_type=std_logic lab=~out5}
C {sky130_fd_pr/nfet_01v8.sym} 2080 -2380 0 0 {name=M67
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2270 -2380 2 0 {name=M68
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2170 -2410 1 0 {name=p163 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2170 -2330 2 0 {name=p164 sig_type=std_logic lab=bot32c}
C {lab_pin.sym} 1790 -2330 2 0 {name=p165 sig_type=std_logic lab=bot32c}
C {lab_pin.sym} 670 -2420 1 0 {name=p166 sig_type=std_logic lab=bot32c}
C {gnd.sym} 2150 -2380 0 0 {name=l38 lab=0}
C {lab_pin.sym} 2230 -2380 0 0 {name=p167 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1790 -2430 2 0 {name=p168 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2040 -2380 0 0 {name=p169 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2300 -2380 2 0 {name=p170 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 350 -2260 0 0 {name=M69
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 500 -2260 0 1 {name=M70
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 400 -2430 0 0 {name=M71
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 400 -2350 0 0 {name=M72
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 420 -2460 1 0 {name=p171 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 290 -2430 0 0 {name=p172 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 370 -2350 0 0 {name=p173 sig_type=std_logic lab=b5}
C {gnd.sym} 420 -2210 0 0 {name=l39 lab=0}
C {lab_pin.sym} 520 -2260 2 0 {name=p174 sig_type=std_logic lab=b5}
C {lab_pin.sym} 450 -2310 2 0 {name=p175 sig_type=std_logic lab=gndb5}
C {sky130_fd_pr/nfet_01v8.sym} 1280 -2260 0 0 {name=M73
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1430 -2260 0 1 {name=M74
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1330 -2430 0 0 {name=M75
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1330 -2350 0 0 {name=M76
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1350 -2460 1 0 {name=p176 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1220 -2430 0 0 {name=p177 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1300 -2350 0 0 {name=p178 sig_type=std_logic lab=~b5}
C {gnd.sym} 1350 -2210 0 0 {name=l40 lab=0}
C {lab_pin.sym} 1450 -2260 2 0 {name=p179 sig_type=std_logic lab=~b5}
C {lab_pin.sym} 1380 -2310 2 0 {name=p180 sig_type=std_logic lab=out5}
C {sky130_fd_pr/nfet_01v8.sym} 1060 -2310 0 0 {name=n12
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1060 -2400 0 0 {name=p181
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1080 -2260 0 0 {name=l41 lab=0}
C {lab_pin.sym} 1080 -2430 0 0 {name=p182 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 980 -2360 0 0 {name=p183 sig_type=std_logic lab=b5
}
C {lab_pin.sym} 1090 -2350 2 0 {name=p184 sig_type=std_logic lab=~b5}
C {sky130_fd_pr/nfet_01v8.sym} 1580 -2320 0 0 {name=n13
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1580 -2410 0 0 {name=p185
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1600 -2270 0 0 {name=l42 lab=0}
C {lab_pin.sym} 1600 -2440 0 0 {name=p186 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1500 -2370 0 0 {name=p187 sig_type=std_logic lab=out5
}
C {lab_pin.sym} 1610 -2360 2 0 {name=p188 sig_type=std_logic lab=~out5}
C {sky130_fd_pr/nfet_01v8.sym} 660 -2920 0 0 {name=M77
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1780 -2910 0 0 {name=M78
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 680 -2890 0 0 {name=l43 lab=0}
C {lab_pin.sym} 640 -2920 3 0 {name=p189 sig_type=std_logic lab=gndb6}
C {lab_pin.sym} 1760 -2910 1 0 {name=p190 sig_type=std_logic lab=~out6}
C {sky130_fd_pr/nfet_01v8.sym} 2090 -2910 0 0 {name=M79
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2280 -2910 2 0 {name=M80
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2180 -2940 1 0 {name=p191 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2180 -2860 2 0 {name=p192 sig_type=std_logic lab=bot64c}
C {lab_pin.sym} 1800 -2860 2 0 {name=p193 sig_type=std_logic lab=bot64c}
C {lab_pin.sym} 680 -2950 1 0 {name=p194 sig_type=std_logic lab=bot64c}
C {gnd.sym} 2160 -2910 0 0 {name=l44 lab=0}
C {lab_pin.sym} 2240 -2910 0 0 {name=p195 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1800 -2960 2 0 {name=p196 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2050 -2910 0 0 {name=p197 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2310 -2910 2 0 {name=p198 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 360 -2790 0 0 {name=M81
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 510 -2790 0 1 {name=M82
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -2960 0 0 {name=M83
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -2880 0 0 {name=M84
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 430 -2990 1 0 {name=p199 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 300 -2960 0 0 {name=p200 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 380 -2880 0 0 {name=p201 sig_type=std_logic lab=b6}
C {gnd.sym} 430 -2740 0 0 {name=l45 lab=0}
C {lab_pin.sym} 530 -2790 2 0 {name=p202 sig_type=std_logic lab=b6}
C {lab_pin.sym} 460 -2840 2 0 {name=p203 sig_type=std_logic lab=gndb6}
C {sky130_fd_pr/nfet_01v8.sym} 1290 -2790 0 0 {name=M85
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1440 -2790 0 1 {name=M86
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1340 -2960 0 0 {name=M87
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1340 -2880 0 0 {name=M88
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1360 -2990 1 0 {name=p204 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1230 -2960 0 0 {name=p205 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1310 -2880 0 0 {name=p206 sig_type=std_logic lab=~b6}
C {gnd.sym} 1360 -2740 0 0 {name=l46 lab=0}
C {lab_pin.sym} 1460 -2790 2 0 {name=p207 sig_type=std_logic lab=~b6}
C {lab_pin.sym} 1390 -2840 2 0 {name=p208 sig_type=std_logic lab=out6}
C {sky130_fd_pr/nfet_01v8.sym} 1070 -2840 0 0 {name=n14
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1070 -2930 0 0 {name=p209
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1090 -2790 0 0 {name=l47 lab=0}
C {lab_pin.sym} 1090 -2960 0 0 {name=p210 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 990 -2890 0 0 {name=p211 sig_type=std_logic lab=b6
}
C {lab_pin.sym} 1100 -2880 2 0 {name=p212 sig_type=std_logic lab=~b6}
C {sky130_fd_pr/nfet_01v8.sym} 1590 -2850 0 0 {name=n15
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1590 -2940 0 0 {name=p213
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1610 -2800 0 0 {name=l48 lab=0}
C {lab_pin.sym} 1610 -2970 0 0 {name=p214 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1510 -2900 0 0 {name=p215 sig_type=std_logic lab=out6
}
C {lab_pin.sym} 1620 -2890 2 0 {name=p216 sig_type=std_logic lab=~out6}
C {sky130_fd_pr/nfet_01v8.sym} 660 -3440 0 0 {name=M89
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1780 -3430 0 0 {name=M90
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 680 -3410 0 0 {name=l49 lab=0}
C {lab_pin.sym} 640 -3440 3 0 {name=p217 sig_type=std_logic lab=gndb7}
C {lab_pin.sym} 1760 -3430 1 0 {name=p218 sig_type=std_logic lab=~out7}
C {sky130_fd_pr/nfet_01v8.sym} 2090 -3430 0 0 {name=M91
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2280 -3430 2 0 {name=M92
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2180 -3460 1 0 {name=p219 sig_type=std_logic lab=vin}
C {lab_pin.sym} 2180 -3380 2 0 {name=p220 sig_type=std_logic lab=bot128c}
C {lab_pin.sym} 1800 -3380 2 0 {name=p221 sig_type=std_logic lab=bot128c}
C {lab_pin.sym} 680 -3470 1 0 {name=p222 sig_type=std_logic lab=bot128c}
C {gnd.sym} 2160 -3430 0 0 {name=l50 lab=0}
C {lab_pin.sym} 2240 -3430 0 0 {name=p223 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1800 -3480 2 0 {name=p224 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 2050 -3430 0 0 {name=p225 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 2310 -3430 2 0 {name=p226 sig_type=std_logic lab=~clock}
C {sky130_fd_pr/nfet_01v8.sym} 360 -3310 0 0 {name=M93
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 510 -3310 0 1 {name=M94
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -3480 0 0 {name=M95
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -3400 0 0 {name=M96
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 430 -3510 1 0 {name=p227 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 300 -3480 0 0 {name=p228 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 380 -3400 0 0 {name=p229 sig_type=std_logic lab=b7}
C {gnd.sym} 430 -3260 0 0 {name=l51 lab=0}
C {lab_pin.sym} 530 -3310 2 0 {name=p230 sig_type=std_logic lab=b7}
C {lab_pin.sym} 460 -3360 2 0 {name=p231 sig_type=std_logic lab=gndb7}
C {sky130_fd_pr/nfet_01v8.sym} 1290 -3310 0 0 {name=M97
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1440 -3310 0 1 {name=M98
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1340 -3480 0 0 {name=M99
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1340 -3400 0 0 {name=M100
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1360 -3510 1 0 {name=p232 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1230 -3480 0 0 {name=p233 sig_type=std_logic lab=clock
}
C {lab_pin.sym} 1310 -3400 0 0 {name=p234 sig_type=std_logic lab=~b7}
C {gnd.sym} 1360 -3260 0 0 {name=l52 lab=0}
C {lab_pin.sym} 1460 -3310 2 0 {name=p235 sig_type=std_logic lab=~b7}
C {lab_pin.sym} 1390 -3360 2 0 {name=p236 sig_type=std_logic lab=out7}
C {sky130_fd_pr/nfet_01v8.sym} 1070 -3360 0 0 {name=n16
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1070 -3450 0 0 {name=p237
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1090 -3310 0 0 {name=l53 lab=0}
C {lab_pin.sym} 1090 -3480 0 0 {name=p238 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 990 -3410 0 0 {name=p239 sig_type=std_logic lab=b7
}
C {lab_pin.sym} 1100 -3400 2 0 {name=p240 sig_type=std_logic lab=~b7}
C {sky130_fd_pr/nfet_01v8.sym} 1590 -3370 0 0 {name=n17
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1590 -3460 0 0 {name=p241
W=2.5
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 1610 -3320 0 0 {name=l54 lab=0}
C {lab_pin.sym} 1610 -3490 0 0 {name=p242 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1510 -3420 0 0 {name=p243 sig_type=std_logic lab=out7
}
C {lab_pin.sym} 1620 -3410 2 0 {name=p244 sig_type=std_logic lab=~out7}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13500 -4720 0 0 {name=C9 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13610 -4720 0 0 {name=C10 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13720 -4720 0 0 {name=C11 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13830 -4720 0 0 {name=C12 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {lab_pin.sym} 13430 -4660 0 0 {name=p245 sig_type=std_logic lab=bot8c}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13040 -4720 0 0 {name=C13 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13150 -4720 0 0 {name=C14 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13260 -4720 0 0 {name=C15 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13370 -4720 0 0 {name=C16 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12530 -4720 0 0 {name=C17 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12640 -4720 0 0 {name=C18 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12750 -4720 0 0 {name=C19 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12860 -4720 0 0 {name=C20 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12070 -4720 0 0 {name=C21 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12180 -4720 0 0 {name=C22 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12290 -4720 0 0 {name=C23 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 12400 -4720 0 0 {name=C24 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11650 -4720 0 0 {name=C25 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11760 -4720 0 0 {name=C26 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11870 -4720 0 0 {name=C27 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11980 -4720 0 0 {name=C28 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11190 -4720 0 0 {name=C29 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11300 -4720 0 0 {name=C30 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11410 -4720 0 0 {name=C31 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11520 -4720 0 0 {name=C32 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {lab_pin.sym} 12030 -4660 0 0 {name=p247 sig_type=std_logic lab=bot16c}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10670 -4720 0 0 {name=C33 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10780 -4720 0 0 {name=C34 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10890 -4720 0 0 {name=C35 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 11000 -4720 0 0 {name=C36 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10210 -4720 0 0 {name=C37 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10320 -4720 0 0 {name=C38 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10430 -4720 0 0 {name=C39 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10540 -4720 0 0 {name=C40 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9790 -4720 0 0 {name=C41 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9900 -4720 0 0 {name=C42 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10010 -4720 0 0 {name=C43 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 10120 -4720 0 0 {name=C44 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9330 -4720 0 0 {name=C45 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9440 -4720 0 0 {name=C46 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9550 -4720 0 0 {name=C47 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9660 -4720 0 0 {name=C48 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8870 -4720 0 0 {name=C49 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8980 -4720 0 0 {name=C50 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9090 -4720 0 0 {name=C51 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9200 -4720 0 0 {name=C52 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8410 -4720 0 0 {name=C53 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8520 -4720 0 0 {name=C54 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8630 -4720 0 0 {name=C55 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8740 -4720 0 0 {name=C56 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7990 -4720 0 0 {name=C57 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8100 -4720 0 0 {name=C58 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8210 -4720 0 0 {name=C59 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8320 -4720 0 0 {name=C60 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7530 -4720 0 0 {name=C61 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7640 -4720 0 0 {name=C62 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7750 -4720 0 0 {name=C63 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7860 -4720 0 0 {name=C64 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {lab_pin.sym} 9260 -4650 0 0 {name=p248 sig_type=std_logic lab=bot32c}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7010 -4720 0 0 {name=C65 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7120 -4720 0 0 {name=C66 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7230 -4720 0 0 {name=C67 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7340 -4720 0 0 {name=C68 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6550 -4720 0 0 {name=C69 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6660 -4720 0 0 {name=C70 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6770 -4720 0 0 {name=C71 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6880 -4720 0 0 {name=C72 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6130 -4720 0 0 {name=C73 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6240 -4720 0 0 {name=C74 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6350 -4720 0 0 {name=C75 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6460 -4720 0 0 {name=C76 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5670 -4720 0 0 {name=C77 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5780 -4720 0 0 {name=C78 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5890 -4720 0 0 {name=C79 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6000 -4720 0 0 {name=C80 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5210 -4720 0 0 {name=C81 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5320 -4720 0 0 {name=C82 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5430 -4720 0 0 {name=C83 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5540 -4720 0 0 {name=C84 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4750 -4720 0 0 {name=C85 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4860 -4720 0 0 {name=C86 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4970 -4720 0 0 {name=C87 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5080 -4720 0 0 {name=C88 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4330 -4720 0 0 {name=C89 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4440 -4720 0 0 {name=C90 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4550 -4720 0 0 {name=C91 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4660 -4720 0 0 {name=C92 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3870 -4720 0 0 {name=C93 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3980 -4720 0 0 {name=C94 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4090 -4720 0 0 {name=C95 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4200 -4720 0 0 {name=C96 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3400 -4720 0 0 {name=C97 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3510 -4720 0 0 {name=C98 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3620 -4720 0 0 {name=C99 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3730 -4720 0 0 {name=C100 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2940 -4720 0 0 {name=C101 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3050 -4720 0 0 {name=C102 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3160 -4720 0 0 {name=C103 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3270 -4720 0 0 {name=C104 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2520 -4720 0 0 {name=C105 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2630 -4720 0 0 {name=C106 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2740 -4720 0 0 {name=C107 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2850 -4720 0 0 {name=C108 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2060 -4720 0 0 {name=C109 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2170 -4720 0 0 {name=C110 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2280 -4720 0 0 {name=C111 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -4720 0 0 {name=C112 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1600 -4720 0 0 {name=C113 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1710 -4720 0 0 {name=C114 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1820 -4720 0 0 {name=C115 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1930 -4720 0 0 {name=C116 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1140 -4720 0 0 {name=C117 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1250 -4720 0 0 {name=C118 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1360 -4720 0 0 {name=C119 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1470 -4720 0 0 {name=C120 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 720 -4720 0 0 {name=C121 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 830 -4720 0 0 {name=C122 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 940 -4720 0 0 {name=C123 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1050 -4720 0 0 {name=C124 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 260 -4720 0 0 {name=C125 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 -4720 0 0 {name=C126 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 480 -4720 0 0 {name=C127 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 590 -4720 0 0 {name=C128 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {lab_pin.sym} 3800 -4670 0 0 {name=p249 sig_type=std_logic lab=bot64c}
C {sky130_fd_pr/cap_mim_m3_1.sym} -220 -4720 0 0 {name=C129 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -110 -4720 0 0 {name=C130 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 0 -4720 0 0 {name=C131 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 110 -4720 0 0 {name=C132 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -680 -4720 0 0 {name=C133 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -570 -4720 0 0 {name=C134 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -460 -4720 0 0 {name=C135 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -350 -4720 0 0 {name=C136 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1100 -4720 0 0 {name=C137 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -990 -4720 0 0 {name=C138 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -880 -4720 0 0 {name=C139 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -770 -4720 0 0 {name=C140 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1560 -4720 0 0 {name=C141 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1450 -4720 0 0 {name=C142 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1340 -4720 0 0 {name=C143 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1230 -4720 0 0 {name=C144 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2020 -4720 0 0 {name=C145 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1910 -4720 0 0 {name=C146 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1800 -4720 0 0 {name=C147 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1690 -4720 0 0 {name=C148 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2480 -4720 0 0 {name=C149 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2370 -4720 0 0 {name=C150 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2260 -4720 0 0 {name=C151 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2150 -4720 0 0 {name=C152 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2900 -4720 0 0 {name=C153 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2790 -4720 0 0 {name=C154 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2680 -4720 0 0 {name=C155 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2570 -4720 0 0 {name=C156 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3360 -4720 0 0 {name=C157 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3250 -4720 0 0 {name=C158 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3140 -4720 0 0 {name=C159 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3030 -4720 0 0 {name=C160 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3830 -4720 0 0 {name=C161 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3720 -4720 0 0 {name=C162 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3610 -4720 0 0 {name=C163 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3500 -4720 0 0 {name=C164 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4290 -4720 0 0 {name=C165 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4180 -4720 0 0 {name=C166 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4070 -4720 0 0 {name=C167 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3960 -4720 0 0 {name=C168 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4710 -4720 0 0 {name=C169 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4600 -4720 0 0 {name=C170 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4490 -4720 0 0 {name=C171 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4380 -4720 0 0 {name=C172 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5170 -4720 0 0 {name=C173 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5060 -4720 0 0 {name=C174 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4950 -4720 0 0 {name=C175 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -4840 -4720 0 0 {name=C176 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5630 -4720 0 0 {name=C177 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5520 -4720 0 0 {name=C178 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5410 -4720 0 0 {name=C179 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5300 -4720 0 0 {name=C180 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6090 -4720 0 0 {name=C181 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5980 -4720 0 0 {name=C182 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5870 -4720 0 0 {name=C183 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -5760 -4720 0 0 {name=C184 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6510 -4720 0 0 {name=C185 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6400 -4720 0 0 {name=C186 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6290 -4720 0 0 {name=C187 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6180 -4720 0 0 {name=C188 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6970 -4720 0 0 {name=C189 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6860 -4720 0 0 {name=C190 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6750 -4720 0 0 {name=C191 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -6640 -4720 0 0 {name=C192 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7420 -4720 0 0 {name=C193 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7310 -4720 0 0 {name=C194 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7200 -4720 0 0 {name=C195 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7090 -4720 0 0 {name=C196 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7880 -4720 0 0 {name=C197 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7770 -4720 0 0 {name=C198 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7660 -4720 0 0 {name=C199 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7550 -4720 0 0 {name=C200 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8300 -4720 0 0 {name=C201 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8190 -4720 0 0 {name=C202 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8080 -4720 0 0 {name=C203 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7970 -4720 0 0 {name=C204 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8760 -4720 0 0 {name=C205 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8650 -4720 0 0 {name=C206 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8540 -4720 0 0 {name=C207 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8430 -4720 0 0 {name=C208 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9220 -4720 0 0 {name=C209 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9110 -4720 0 0 {name=C210 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9000 -4720 0 0 {name=C211 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8890 -4720 0 0 {name=C212 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9680 -4720 0 0 {name=C213 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9570 -4720 0 0 {name=C214 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9460 -4720 0 0 {name=C215 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9350 -4720 0 0 {name=C216 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10100 -4720 0 0 {name=C217 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9990 -4720 0 0 {name=C218 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9880 -4720 0 0 {name=C219 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -9770 -4720 0 0 {name=C220 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10560 -4720 0 0 {name=C221 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10450 -4720 0 0 {name=C222 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10340 -4720 0 0 {name=C223 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10230 -4720 0 0 {name=C224 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11030 -4720 0 0 {name=C225 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10920 -4720 0 0 {name=C226 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10810 -4720 0 0 {name=C227 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -10700 -4720 0 0 {name=C228 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11490 -4720 0 0 {name=C229 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11380 -4720 0 0 {name=C230 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11270 -4720 0 0 {name=C231 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11160 -4720 0 0 {name=C232 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11910 -4720 0 0 {name=C233 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11800 -4720 0 0 {name=C234 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11690 -4720 0 0 {name=C235 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -11580 -4720 0 0 {name=C236 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12370 -4720 0 0 {name=C237 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12260 -4720 0 0 {name=C238 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12150 -4720 0 0 {name=C239 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12040 -4720 0 0 {name=C240 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12830 -4720 0 0 {name=C241 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12720 -4720 0 0 {name=C242 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12610 -4720 0 0 {name=C243 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12500 -4720 0 0 {name=C244 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13290 -4720 0 0 {name=C245 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13180 -4720 0 0 {name=C246 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13070 -4720 0 0 {name=C247 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -12960 -4720 0 0 {name=C248 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13710 -4720 0 0 {name=C249 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13600 -4720 0 0 {name=C250 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13490 -4720 0 0 {name=C251 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13380 -4720 0 0 {name=C252 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -14170 -4720 0 0 {name=C253 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -14060 -4720 0 0 {name=C254 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13950 -4720 0 0 {name=C255 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -13840 -4720 0 0 {name=C256 model=cap_mim_m3_1 W=3 L=3 MF=1 spiceprefix=X}
C {lab_pin.sym} -7030 -4670 0 0 {name=p246 sig_type=std_logic lab=bot128c}
